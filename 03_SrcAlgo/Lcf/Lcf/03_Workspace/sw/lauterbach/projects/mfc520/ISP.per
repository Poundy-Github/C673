CONFIG 16.  8.
WIDTH 8
TREE.OPEN "ISP Registers"
BASE asd:0xfec00000
TREE "Interrupts"
group.long 0x80++0x3
line.long 0x00 "0x0080"
textline "                 "
bitfld.long 0x00 0. " Isp sensor1  ,   "
bitfld.long 0x00 1. " Isp sensor2  ,   "
bitfld.long 0x00 2. " Isp sensor3  ,   "
bitfld.long 0x00 3. " Isp sensor4  ,   "
textline "                 "
bitfld.long 0x00 4. " Isp start1  ,   "
bitfld.long 0x00 5. " Isp start2  ,   "
bitfld.long 0x00 6. " Isp start3  ,   "
bitfld.long 0x00 7. " Isp start4  ,   "
textline "                 "
bitfld.long 0x00 8. " Isp start  ,   "
bitfld.long 0x00 9. " Isp stitched  ,   "
bitfld.long 0x00 10. " Isp defect pixel  ,   "
bitfld.long 0x00 11. " Isp sinter  ,   "
textline "                 "
bitfld.long 0x00 12. " Isp shading  ,   "
bitfld.long 0x00 13. " Isp iridix  ,   "
bitfld.long 0x00 14. " Isp demosaic  ,   "
bitfld.long 0x00 15. " Isp out  ,   "
group.long 0x84++0x3
line.long 0x00 "0x0084"
hexmask.long.word 0x00 0.--15. 1. " Frame start mask  ,Interrupt mask for frame start events"
rgroup.long 0x88++0x3
line.long 0x00 "0x0088"
hexmask.long.word 0x00 0.--15. 1. " Frame start status  ,Interrupt status bits for frame start events"
group.long 0x8c++0x3
line.long 0x00 "0x008c"
hexmask.long.word 0x00 0.--15. 1. " Frame start clear  ,Clearing of interrupt status bits"
group.long 0x90++0x3
line.long 0x00 "0x0090"
hexmask.long.word 0x00 0.--15. 1. " Frame start level0  ,Interrupt level bit 0 for frame start events"
group.long 0x94++0x3
line.long 0x00 "0x0094"
hexmask.long.word 0x00 0.--15. 1. " Frame start level1  ,Interrupt level bit 1 for frame start events"
group.long 0x98++0x3
line.long 0x00 "0x0098"
hexmask.long.word 0x00 0.--15. 1. " Frame end mask  ,Interrupt mask for frame end events"
rgroup.long 0x9c++0x3
line.long 0x00 "0x009c"
hexmask.long.word 0x00 0.--15. 1. " Frame end status  ,Interrupt status bits for frame end events"
group.long 0xa0++0x3
line.long 0x00 "0x00a0"
hexmask.long.word 0x00 0.--15. 1. " Frame end clear  ,Clearing of interrupt status bits"
group.long 0xa4++0x3
line.long 0x00 "0x00a4"
hexmask.long.word 0x00 0.--15. 1. " Frame end level0  ,Interrupt level bit 0 for frame end events"
group.long 0xa8++0x3
line.long 0x00 "0x00a8"
hexmask.long.word 0x00 0.--15. 1. " Frame end level1  ,Interrupt level bit 1 for frame end events"
group.long 0xac++0x3
line.long 0x00 "0x00ac"
textline "                 "
bitfld.long 0x00 0. " Metering aexp  ,   "
bitfld.long 0x00 1. " Metering awb  ,   "
bitfld.long 0x00 2. " Metering hist 1  ,   "
bitfld.long 0x00 3. " Metering hist 2  ,   "
textline "                 "
bitfld.long 0x00 4. " Metering hist 3  ,   "
bitfld.long 0x00 5. " Metering hist 4  ,   "
bitfld.long 0x00 6. " Antifog hist  ,   "
bitfld.long 0x00 7. " Roi hist 1  ,   "
textline "                 "
bitfld.long 0x00 8. " Roi hist 2  ,   "
bitfld.long 0x00 9. " Roi hist 3  ,   "
bitfld.long 0x00 10. " Roi hist 4  ,   "
bitfld.long 0x00 11. " Uroi  ,   "
textline "                 "
bitfld.long 0x00 12. " Iridix  ,   "
bitfld.long 0x00 13. " Defect pixel  ,   "
bitfld.long 0x00 14. " Bist status  ,   "
bitfld.long 0x00 15. " Slot 1  ,   "
textline "                 "
bitfld.long 0x00 16. " Slot 2  ,   "
bitfld.long 0x00 17. " Slot 3  ,   "
bitfld.long 0x00 18. " Slot 4  ,   "
bitfld.long 0x00 19. " Slot 5  ,   "
textline "                 "
bitfld.long 0x00 20. " Slot 6  ,   "
bitfld.long 0x00 21. " Input cdma 1  ,   "
bitfld.long 0x00 22. " Input cdma 2  ,   "
bitfld.long 0x00 23. " Input cdma 3  ,   "
textline "                 "
bitfld.long 0x00 24. " Input cdma 4  ,   "
group.long 0xb0++0x3
line.long 0x00 "0x00b0"
hexmask.long.long 0x00 0.--24. 1. " Stats mask  ,Interrupt mask for module events"
rgroup.long 0xb4++0x3
line.long 0x00 "0x00b4"
hexmask.long.long 0x00 0.--24. 1. " Stats status  ,interrupt status bits for module events"
group.long 0xb8++0x3
line.long 0x00 "0x00b8"
hexmask.long.long 0x00 0.--24. 1. " Stats clear  ,Clearing of interrupt status bits"
group.long 0xbc++0x3
line.long 0x00 "0x00bc"
hexmask.long.long 0x00 0.--24. 1. " Stats level0  ,Interrupt level bit 0 for module events"
group.long 0xc0++0x3
line.long 0x00 "0x00c0"
hexmask.long.long 0x00 0.--24. 1. " Stats level1  ,Interrupt level bit 1 for module events"
group.long 0xc4++0x3
line.long 0x00 "0x00c4"
hexmask.long.byte 0x00 0.--3. 1. " Interrupt trigger  ,Manual triggering of the interrupt outputs"
TREE.END
TREE "Input port 1"
group.long 0x100++0x3
line.long 0x00 "0x0100"
hexmask.long.byte 0x00 0.--3. 1. " Preset  ,Allows selection of various input port presets for standard sensor inputs.  See ISP Guide for details of available presets.         0-14: Frequently used presets.  If using one of available presets, remaining bits in registers 0x100 and 0x104 are not used.         15:   Input port configured according to registers in 0x100 and 0x104.  Consult Apical support for special input port requirements."
textline "                 "
bitfld.long 0x00 8. " VS use field  , 0=use vsync_i port for vertical sync, 1=use field_i port for vertical sync  "
bitfld.long 0x00 9. " VS toggle  , 0=vsync is pulse-type, 1=vsync is toggle-type (field signal)  "
bitfld.long 0x00 10. " VS polarity  , 0=horizontal counter reset on rising edge, 1=horizontal counter reset on falling edge  "
bitfld.long 0x00 11. " VS polarity acl  , 0=don't invert polarity for ACL gate, 1=invert polarity for ACL gate  "
textline "                 "
bitfld.long 0x00 12. " HS use acl  , 0=use hsync_i port for active-line, 1=use acl_i port for active-line  "
bitfld.long 0x00 14. " VC C select  , 0=vertical counter counts on hs, 1=vertical counter counts on horizontal counter overflow or reset  "
bitfld.long 0x00 15. " VC R select  , 0=vertical counter is reset on edge of vs, 1=vertical counter is reset after timeout on hs  "
bitfld.long 0x00 16. " HS xor VS  , 0=normal mode, 1=hvalid = hsync XOR vsync  "
textline "                 "
bitfld.long 0x00 17. " HS polarity  , 0=don't invert polarity of HS for ACL gate, 1=invert polarity of HS for ACL gate  "
bitfld.long 0x00 18. " HS polarity acl  , 0=don't invert polarity of HS for HS gate, 1=invert polarity of HS for HS gate  "
bitfld.long 0x00 19. " HS polarity hs  , 0=horizontal counter is reset on rising edge of hs, 1=horizontal counter is reset on vsync (e.g. when hsync is not available)  "
bitfld.long 0x00 20. " HS polarity vc  , 0=vertical counter increments on rising edge of HS, 1=vertical counter increments on falling edge of HS  "
textline "                 "
bitfld.long 0x00 23. " HC R select  , 0=vertical counter is reset on rising edge of hs, 1=vertical counter is reset on rising edge of vs  "
bitfld.long 0x00 24. " Acl polarity  , 0=don't invert acl_i for acl gate, 1=invert acl_i for acl gate  "
group.long 0x104++0x3
line.long 0x00 "0x0104"
bitfld.long 0x00 0. " Field polarity  , 0=don't invert field_i for field gate, 1=invert field_i for field gate  "
bitfld.long 0x00 1. " Field toggle  , 0=field is pulse-type, 1=field is toggle-type  "
textline "                 "
bitfld.long 0x00 8. " Aclg window0  , 0=exclude window0 signal in ACL gate, 1=include window0 signal in ACL gate  "
bitfld.long 0x00 9. " Aclg HSync  , 0=exclude hsync signal in ACL gate, 1=include hsync signal in ACL gate  "
bitfld.long 0x00 10. " Aclg window2  , 0=exclude window2 signal in ACL gate, 1=include window2 signal in ACL gate  "
bitfld.long 0x00 11. " Aclg acl  , 0=exclude acl_i signal in ACL gate, 1=include acl_i signal in ACL gate  "
textline "                 "
bitfld.long 0x00 12. " Aclg vsync  , 0=exclude vsync signal in ACL gate, 1=include vsync signal in ACL gate  "
bitfld.long 0x00 16. " HSg window1  , 0=exclude window1 signal in HS gate, 1=include window1 signal in HS gate  "
bitfld.long 0x00 17. " HSg hsync  , 0=exclude hsync signal in HS gate, 1=include hsync signal in HS gate  "
bitfld.long 0x00 18. " HSg vsync  , 0=exclude vsync signal in HS gate, 1=include vsync signal in HS gate  "
textline "                 "
bitfld.long 0x00 19. " HSg window2  , 0=exclude window2 signal in HS gate, 1=include window2 signal in HS gate (mask out spurious hs during blank)  "
bitfld.long 0x00 24. " Fieldg vsync  , 0=exclude vsync signal in Field gate, 1=include vsync signal in Field gate  "
bitfld.long 0x00 25. " Fieldg window2  , 0=exclude window2 signal in Field gate, 1=include window2 signal in Field gate  "
bitfld.long 0x00 26. " Fieldg field  , 0=exclude field_i signal in Field gate, 1=include field_i signal in Field gate  "
textline "                 "
bitfld.long 0x00 27. " field mode  , 0=pulse field, 1=toggle field  "
group.long 0x108++0x3
line.long 0x00 "0x0108"
hexmask.long.word 0x00 0.--15. 1. " Hc limit  ,horizontal counter limit value (counts: 0,1,...hc_limit-1,hc_limit,0,1,...)"
group.long 0x10c++0x3
line.long 0x00 "0x010c"
hexmask.long.word 0x00 0.--15. 1. " Hc start0  ,window0 start for ACL gate.  See ISP guide for further details."
group.long 0x110++0x3
line.long 0x00 "0x0110"
hexmask.long.word 0x00 0.--15. 1. " Hc size0  ,window0 size for ACL gate.  See ISP guide for further details."
group.long 0x114++0x3
line.long 0x00 "0x0114"
hexmask.long.word 0x00 0.--15. 1. " Hc start1  ,window1 start for HS gate.  See ISP guide for further details."
group.long 0x118++0x3
line.long 0x00 "0x0118"
hexmask.long.word 0x00 0.--15. 1. " Hc size1  ,window1 size for HS gate.  See ISP guide for further details."
group.long 0x11c++0x3
line.long 0x00 "0x011c"
hexmask.long.word 0x00 0.--15. 1. " Vc limit  ,vertical counter limit value (counts: 0,1,...vc_limit-1,vc_limit,0,1,...)"
group.long 0x120++0x3
line.long 0x00 "0x0120"
hexmask.long.word 0x00 0.--15. 1. " Vc start  ,window2 start for ACL gate.  See ISP guide for further details."
group.long 0x124++0x3
line.long 0x00 "0x0124"
hexmask.long.word 0x00 0.--15. 1. " Vc size  ,window2 size for ACL gate.  See ISP guide for further details."
rgroup.long 0x128++0x3
line.long 0x00 "0x0128"
hexmask.long.word 0x00 0.--15. 1. " Frame width  ,detected frame width.  Read only value."
rgroup.long 0x12c++0x3
line.long 0x00 "0x012c"
hexmask.long.word 0x00 0.--15. 1. " Frame height  ,detected frame height.  Read only value."
group.long 0x1f0++0x3
line.long 0x00 "0x01f0"
textline "                 "
bitfld.long 0x00 7. " Freeze config  , Used to freeze input port configuration.  Used when multiple register writes are required to change input port configuration. (0=normal operation, 1=hold previous input port config state)  "
hexmask.long.byte 0x00 0.--2. 1. " Mode request  ,Used to stop and start input port.  See ISP guide for further details. (0=safe stop, 1=safe start, 2=urgent stop, 3=urgent start, 4=reserved4, 5=safer start, 6=reserved6, 7=reserved7)"
rgroup.long 0x1f4++0x3
line.long 0x00 "0x01f4"
hexmask.long.byte 0x00 0.--2. 1. " Mode status  ,Used to monitor input port status:       bit 0: 1=running, 0=stopped, bits 1,2-reserved"
TREE.END
TREE "Input port 2"
group.long 0x140++0x3
line.long 0x00 "0x0140"
hexmask.long.byte 0x00 0.--3. 1. " preset  ,Allows selection of various input port presets for standard sensor inputs.  See ISP Guide for details of available presets.         0-14: Frequently used presets.  If using one of available presets, remaining bits in registers 0x100 and 0x104 are not used.         15:   Input port configured according to registers in 0x100 and 0x104.  Consult Apical support for special input port requirements."
textline "                 "
bitfld.long 0x00 8. " vs_use field  , 0=use vsync_i port for vertical sync, 1=use field_i port for vertical sync  "
bitfld.long 0x00 9. " vs toggle  , 0=vsync is pulse-type, 1=vsync is toggle-type (field signal)  "
bitfld.long 0x00 10. " vs polarity  , 0=horizontal counter reset on rising edge, 1=horizontal counter reset on falling edge  "
bitfld.long 0x00 11. " vs_polarity acl  , 0=don't invert polarity for ACL gate, 1=invert polarity for ACL gate  "
textline "                 "
bitfld.long 0x00 12. " hs_use acl  , 0=use hsync_i port for active-line, 1=use acl_i port for active-line  "
bitfld.long 0x00 14. " vc_c select  , 0=vertical counter counts on hs, 1=vertical counter counts on horizontal counter overflow or reset  "
bitfld.long 0x00 15. " vc_r select  , 0=vertical counter is reset on edge of vs, 1=vertical counter is reset after timeout on hs  "
bitfld.long 0x00 16. " hs_xor vs  , 0=normal mode, 1=hvalid = hsync XOR vsync  "
textline "                 "
bitfld.long 0x00 17. " hs polarity  , 0=don't invert polarity of HS for ACL gate, 1=invert polarity of HS for ACL gate  "
bitfld.long 0x00 18. " hs_polarity acl  , 0=don't invert polarity of HS for HS gate, 1=invert polarity of HS for HS gate  "
bitfld.long 0x00 19. " hs_polarity hs  , 0=horizontal counter is reset on rising edge of hs, 1=horizontal counter is reset on vsync (e.g. when hsync is not available)  "
bitfld.long 0x00 20. " hs_polarity vc  , 0=vertical counter increments on rising edge of HS, 1=vertical counter increments on falling edge of HS  "
textline "                 "
bitfld.long 0x00 23. " hc_r select  , 0=vertical counter is reset on rising edge of hs, 1=vertical counter is reset on rising edge of vs  "
bitfld.long 0x00 24. " acl polarity  , 0=don't invert acl_i for acl gate, 1=invert acl_i for acl gate  "
group.long 0x144++0x3
line.long 0x00 "0x0144"
bitfld.long 0x00 0. " field polarity  , 0=don't invert field_i for field gate, 1=invert field_i for field gate  "
bitfld.long 0x00 1. " field toggle  , 0=field is pulse-type, 1=field is toggle-type  "
textline "                 "
bitfld.long 0x00 8. " aclg window0  , 0=exclude window0 signal in ACL gate, 1=include window0 signal in ACL gate  "
bitfld.long 0x00 9. " aclg hsync  , 0=exclude hsync signal in ACL gate, 1=include hsync signal in ACL gate  "
bitfld.long 0x00 10. " aclg window2  , 0=exclude window2 signal in ACL gate, 1=include window2 signal in ACL gate  "
bitfld.long 0x00 11. " aclg acl  , 0=exclude acl_i signal in ACL gate, 1=include acl_i signal in ACL gate  "
textline "                 "
bitfld.long 0x00 12. " aclg vsync  , 0=exclude vsync signal in ACL gate, 1=include vsync signal in ACL gate  "
bitfld.long 0x00 16. " hsg window1  , 0=exclude window1 signal in HS gate, 1=include window1 signal in HS gate  "
bitfld.long 0x00 17. " hsg hsync  , 0=exclude hsync signal in HS gate, 1=include hsync signal in HS gate  "
bitfld.long 0x00 18. " hsg vsync  , 0=exclude vsync signal in HS gate, 1=include vsync signal in HS gate  "
textline "                 "
bitfld.long 0x00 19. " hsg window2  , 0=exclude window2 signal in HS gate, 1=include window2 signal in HS gate (mask out spurious hs during blank)  "
bitfld.long 0x00 24. " fieldg vsync  , 0=exclude vsync signal in Field gate, 1=include vsync signal in Field gate  "
bitfld.long 0x00 25. " fieldg window2  , 0=exclude window2 signal in Field gate, 1=include window2 signal in Field gate  "
bitfld.long 0x00 26. " fieldg field  , 0=exclude field_i signal in Field gate, 1=include field_i signal in Field gate  "
textline "                 "
bitfld.long 0x00 27. " field mode  , 0=pulse field, 1=toggle field  "
group.long 0x148++0x3
line.long 0x00 "0x0148"
hexmask.long.word 0x00 0.--15. 1. " hc limit  ,horizontal counter limit value (counts: 0,1,...hc_limit-1,hc_limit,0,1,...)"
group.long 0x14c++0x3
line.long 0x00 "0x014c"
hexmask.long.word 0x00 0.--15. 1. " hc start0  ,window0 start for ACL gate.  See ISP guide for further details."
group.long 0x150++0x3
line.long 0x00 "0x0150"
hexmask.long.word 0x00 0.--15. 1. " hc size0  ,window0 size for ACL gate.  See ISP guide for further details."
group.long 0x154++0x3
line.long 0x00 "0x0154"
hexmask.long.word 0x00 0.--15. 1. " hc start1  ,window1 start for HS gate.  See ISP guide for further details."
group.long 0x158++0x3
line.long 0x00 "0x0158"
hexmask.long.word 0x00 0.--15. 1. " hc size1  ,window1 size for HS gate.  See ISP guide for further details."
group.long 0x15c++0x3
line.long 0x00 "0x015c"
hexmask.long.word 0x00 0.--15. 1. " vc limit  ,vertical counter limit value (counts: 0,1,...vc_limit-1,vc_limit,0,1,...)"
group.long 0x160++0x3
line.long 0x00 "0x0160"
hexmask.long.word 0x00 0.--15. 1. " vc start  ,window2 start for ACL gate.  See ISP guide for further details."
group.long 0x164++0x3
line.long 0x00 "0x0164"
hexmask.long.word 0x00 0.--15. 1. " vc size  ,window2 size for ACL gate.  See ISP guide for further details."
rgroup.long 0x168++0x3
line.long 0x00 "0x0168"
hexmask.long.word 0x00 0.--15. 1. " frame width  ,detected frame width.  Read only value."
rgroup.long 0x16c++0x3
line.long 0x00 "0x016c"
hexmask.long.word 0x00 0.--15. 1. " frame height  ,detected frame height.  Read only value."
group.long 0x1f0++0x3
line.long 0x00 "0x01f1"
textline "                 "
bitfld.long 0x00 15. " freeze config  , Used to freeze input port configuration.  Used when multiple register writes are required to change input port configuration. (0=normal operation, 1=hold previous input port config state)  "
hexmask.long.byte 0x00 8.--10. 1. " mode request  ,Used to stop and start input port.  See ISP guide for further details. (0=safe stop, 1=safe start, 2=urgent stop, 3=urgent start, 4=reserved4, 5=safer start, 6=reserved6, 7=reserved7)"
rgroup.long 0x1f4++0x3
line.long 0x00 "0x01f4"
hexmask.long.byte 0x00 8.--10. 1. " mode status  ,Used to monitor input port status:       bit 0: 1=running, 0=stopped, bits 1,2-reserved"
TREE.END
TREE "Input port 3"
group.long 0x180++0x3
line.long 0x00 "0x0180"
hexmask.long.byte 0x00 0.--3. 1. " preset  ,Allows selection of various input port presets for standard sensor inputs.  See ISP Guide for details of available presets.         0-14: Frequently used presets.  If using one of available presets, remaining bits in registers 0x100 and 0x104 are not used.         15:   Input port configured according to registers in 0x100 and 0x104.  Consult Apical support for special input port requirements."
textline "                 "
bitfld.long 0x00 8. " vs_use field  , 0=use vsync_i port for vertical sync, 1=use field_i port for vertical sync  "
bitfld.long 0x00 9. " vs toggle  , 0=vsync is pulse-type, 1=vsync is toggle-type (field signal)  "
bitfld.long 0x00 10. " vs polarity  , 0=horizontal counter reset on rising edge, 1=horizontal counter reset on falling edge  "
bitfld.long 0x00 11. " vs_polarity acl  , 0=don't invert polarity for ACL gate, 1=invert polarity for ACL gate  "
textline "                 "
bitfld.long 0x00 12. " hs_use acl  , 0=use hsync_i port for active-line, 1=use acl_i port for active-line  "
bitfld.long 0x00 14. " vc_c select  , 0=vertical counter counts on hs, 1=vertical counter counts on horizontal counter overflow or reset  "
bitfld.long 0x00 15. " vc_r select  , 0=vertical counter is reset on edge of vs, 1=vertical counter is reset after timeout on hs  "
bitfld.long 0x00 16. " hs_xor vs  , 0=normal mode, 1=hvalid = hsync XOR vsync  "
textline "                 "
bitfld.long 0x00 17. " hs polarity  , 0=don't invert polarity of HS for ACL gate, 1=invert polarity of HS for ACL gate  "
bitfld.long 0x00 18. " hs_polarity acl  , 0=don't invert polarity of HS for HS gate, 1=invert polarity of HS for HS gate  "
bitfld.long 0x00 19. " hs_polarity hs  , 0=horizontal counter is reset on rising edge of hs, 1=horizontal counter is reset on vsync (e.g. when hsync is not available)  "
bitfld.long 0x00 20. " hs_polarity vc  , 0=vertical counter increments on rising edge of HS, 1=vertical counter increments on falling edge of HS  "
textline "                 "
bitfld.long 0x00 23. " hc_r select  , 0=vertical counter is reset on rising edge of hs, 1=vertical counter is reset on rising edge of vs  "
bitfld.long 0x00 24. " acl polarity  , 0=don't invert acl_i for acl gate, 1=invert acl_i for acl gate  "
group.long 0x184++0x3
line.long 0x00 "0x0184"
bitfld.long 0x00 0. " field polarity  , 0=don't invert field_i for field gate, 1=invert field_i for field gate  "
bitfld.long 0x00 1. " field toggle  , 0=field is pulse-type, 1=field is toggle-type  "
textline "                 "
bitfld.long 0x00 8. " aclg window0  , 0=exclude window0 signal in ACL gate, 1=include window0 signal in ACL gate  "
bitfld.long 0x00 9. " aclg hsync  , 0=exclude hsync signal in ACL gate, 1=include hsync signal in ACL gate  "
bitfld.long 0x00 10. " aclg window2  , 0=exclude window2 signal in ACL gate, 1=include window2 signal in ACL gate  "
bitfld.long 0x00 11. " aclg acl  , 0=exclude acl_i signal in ACL gate, 1=include acl_i signal in ACL gate  "
textline "                 "
bitfld.long 0x00 12. " aclg vsync  , 0=exclude vsync signal in ACL gate, 1=include vsync signal in ACL gate  "
bitfld.long 0x00 16. " hsg window1  , 0=exclude window1 signal in HS gate, 1=include window1 signal in HS gate  "
bitfld.long 0x00 17. " hsg hsync  , 0=exclude hsync signal in HS gate, 1=include hsync signal in HS gate  "
bitfld.long 0x00 18. " hsg vsync  , 0=exclude vsync signal in HS gate, 1=include vsync signal in HS gate  "
textline "                 "
bitfld.long 0x00 19. " hsg window2  , 0=exclude window2 signal in HS gate, 1=include window2 signal in HS gate (mask out spurious hs during blank)  "
bitfld.long 0x00 24. " fieldg vsync  , 0=exclude vsync signal in Field gate, 1=include vsync signal in Field gate  "
bitfld.long 0x00 25. " fieldg window2  , 0=exclude window2 signal in Field gate, 1=include window2 signal in Field gate  "
bitfld.long 0x00 26. " fieldg field  , 0=exclude field_i signal in Field gate, 1=include field_i signal in Field gate  "
textline "                 "
bitfld.long 0x00 27. " field mode  , 0=pulse field, 1=toggle field  "
group.long 0x188++0x3
line.long 0x00 "0x0188"
hexmask.long.word 0x00 0.--15. 1. " hc limit  ,horizontal counter limit value (counts: 0,1,...hc_limit-1,hc_limit,0,1,...)"
group.long 0x18c++0x3
line.long 0x00 "0x018c"
hexmask.long.word 0x00 0.--15. 1. " hc start0  ,window0 start for ACL gate.  See ISP guide for further details."
group.long 0x190++0x3
line.long 0x00 "0x0190"
hexmask.long.word 0x00 0.--15. 1. " hc size0  ,window0 size for ACL gate.  See ISP guide for further details."
group.long 0x194++0x3
line.long 0x00 "0x0194"
hexmask.long.word 0x00 0.--15. 1. " hc start1  ,window1 start for HS gate.  See ISP guide for further details."
group.long 0x198++0x3
line.long 0x00 "0x0198"
hexmask.long.word 0x00 0.--15. 1. " hc size1  ,window1 size for HS gate.  See ISP guide for further details."
group.long 0x19c++0x3
line.long 0x00 "0x019c"
hexmask.long.word 0x00 0.--15. 1. " vc limit  ,vertical counter limit value (counts: 0,1,...vc_limit-1,vc_limit,0,1,...)"
group.long 0x1a0++0x3
line.long 0x00 "0x01a0"
hexmask.long.word 0x00 0.--15. 1. " vc start  ,window2 start for ACL gate.  See ISP guide for further details."
group.long 0x1a4++0x3
line.long 0x00 "0x01a4"
hexmask.long.word 0x00 0.--15. 1. " vc size  ,window2 size for ACL gate.  See ISP guide for further details."
rgroup.long 0x1a8++0x3
line.long 0x00 "0x01a8"
hexmask.long.word 0x00 0.--15. 1. " frame width  ,detected frame width.  Read only value."
rgroup.long 0x1ac++0x3
line.long 0x00 "0x01ac"
hexmask.long.word 0x00 0.--15. 1. " frame height  ,detected frame height.  Read only value."
group.long 0x1f0++0x3
line.long 0x00 "0x01f2"
textline "                 "
bitfld.long 0x00 23. " freeze config  , Used to freeze input port configuration.  Used when multiple register writes are required to change input port configuration. (0=normal operation, 1=hold previous input port config state)  "
hexmask.long.byte 0x00 16.--18. 1. " mode request  ,Used to stop and start input port.  See ISP guide for further details. (0=safe stop, 1=safe start, 2=urgent stop, 3=urgent start, 4=reserved4, 5=safer start, 6=reserved6, 7=reserved7)"
rgroup.long 0x1f4++0x3
line.long 0x00 "0x01f4"
hexmask.long.byte 0x00 16.--18. 1. " mode status  ,Used to monitor input port status:       bit 0: 1=running, 0=stopped, bits 1,2-reserved"
TREE.END
TREE "Input port 4"
group.long 0x1c0++0x3
line.long 0x00 "0x01c0"
hexmask.long.byte 0x00 0.--3. 1. " preset  ,Allows selection of various input port presets for standard sensor inputs.  See ISP Guide for details of available presets.         0-14: Frequently used presets.  If using one of available presets, remaining bits in registers 0x100 and 0x104 are not used.         15:   Input port configured according to registers in 0x100 and 0x104.  Consult Apical support for special input port requirements."
textline "                 "
bitfld.long 0x00 8. " vs_use field  , 0=use vsync_i port for vertical sync, 1=use field_i port for vertical sync  "
bitfld.long 0x00 9. " vs toggle  , 0=vsync is pulse-type, 1=vsync is toggle-type (field signal)  "
bitfld.long 0x00 10. " vs polarity  , 0=horizontal counter reset on rising edge, 1=horizontal counter reset on falling edge  "
bitfld.long 0x00 11. " vs_polarity acl  , 0=don't invert polarity for ACL gate, 1=invert polarity for ACL gate  "
textline "                 "
bitfld.long 0x00 12. " hs_use acl  , 0=use hsync_i port for active-line, 1=use acl_i port for active-line  "
bitfld.long 0x00 14. " vc_c select  , 0=vertical counter counts on hs, 1=vertical counter counts on horizontal counter overflow or reset  "
bitfld.long 0x00 15. " vc_r select  , 0=vertical counter is reset on edge of vs, 1=vertical counter is reset after timeout on hs  "
bitfld.long 0x00 16. " hs_xor vs  , 0=normal mode, 1=hvalid = hsync XOR vsync  "
textline "                 "
bitfld.long 0x00 17. " hs polarity  , 0=don't invert polarity of HS for ACL gate, 1=invert polarity of HS for ACL gate  "
bitfld.long 0x00 18. " hs_polarity acl  , 0=don't invert polarity of HS for HS gate, 1=invert polarity of HS for HS gate  "
bitfld.long 0x00 19. " hs_polarity hs  , 0=horizontal counter is reset on rising edge of hs, 1=horizontal counter is reset on vsync (e.g. when hsync is not available)  "
bitfld.long 0x00 20. " hs_polarity vc  , 0=vertical counter increments on rising edge of HS, 1=vertical counter increments on falling edge of HS  "
textline "                 "
bitfld.long 0x00 23. " hc_r select  , 0=vertical counter is reset on rising edge of hs, 1=vertical counter is reset on rising edge of vs  "
bitfld.long 0x00 24. " acl polarity  , 0=don't invert acl_i for acl gate, 1=invert acl_i for acl gate  "
group.long 0x1c4++0x3
line.long 0x00 "0x01c4"
bitfld.long 0x00 0. " field polarity  , 0=don't invert field_i for field gate, 1=invert field_i for field gate  "
bitfld.long 0x00 1. " field toggle  , 0=field is pulse-type, 1=field is toggle-type  "
textline "                 "
bitfld.long 0x00 8. " aclg window0  , 0=exclude window0 signal in ACL gate, 1=include window0 signal in ACL gate  "
bitfld.long 0x00 9. " aclg hsync  , 0=exclude hsync signal in ACL gate, 1=include hsync signal in ACL gate  "
bitfld.long 0x00 10. " aclg window2  , 0=exclude window2 signal in ACL gate, 1=include window2 signal in ACL gate  "
bitfld.long 0x00 11. " aclg acl  , 0=exclude acl_i signal in ACL gate, 1=include acl_i signal in ACL gate  "
textline "                 "
bitfld.long 0x00 12. " aclg vsync  , 0=exclude vsync signal in ACL gate, 1=include vsync signal in ACL gate  "
bitfld.long 0x00 16. " hsg window1  , 0=exclude window1 signal in HS gate, 1=include window1 signal in HS gate  "
bitfld.long 0x00 17. " hsg hsync  , 0=exclude hsync signal in HS gate, 1=include hsync signal in HS gate  "
bitfld.long 0x00 18. " hsg vsync  , 0=exclude vsync signal in HS gate, 1=include vsync signal in HS gate  "
textline "                 "
bitfld.long 0x00 19. " hsg window2  , 0=exclude window2 signal in HS gate, 1=include window2 signal in HS gate (mask out spurious hs during blank)  "
bitfld.long 0x00 24. " fieldg vsync  , 0=exclude vsync signal in Field gate, 1=include vsync signal in Field gate  "
bitfld.long 0x00 25. " fieldg window2  , 0=exclude window2 signal in Field gate, 1=include window2 signal in Field gate  "
bitfld.long 0x00 26. " fieldg field  , 0=exclude field_i signal in Field gate, 1=include field_i signal in Field gate  "
textline "                 "
bitfld.long 0x00 27. " field mode  , 0=pulse field, 1=toggle field  "
group.long 0x1c8++0x3
line.long 0x00 "0x01c8"
hexmask.long.word 0x00 0.--15. 1. " hc limit  ,horizontal counter limit value (counts: 0,1,...hc_limit-1,hc_limit,0,1,...)"
group.long 0x1cc++0x3
line.long 0x00 "0x01cc"
hexmask.long.word 0x00 0.--15. 1. " hc start0  ,window0 start for ACL gate.  See ISP guide for further details."
group.long 0x1d0++0x3
line.long 0x00 "0x01d0"
hexmask.long.word 0x00 0.--15. 1. " hc size0  ,window0 size for ACL gate.  See ISP guide for further details."
group.long 0x1d4++0x3
line.long 0x00 "0x01d4"
hexmask.long.word 0x00 0.--15. 1. " hc start1  ,window1 start for HS gate.  See ISP guide for further details."
group.long 0x1d8++0x3
line.long 0x00 "0x01d8"
hexmask.long.word 0x00 0.--15. 1. " hc size1  ,window1 size for HS gate.  See ISP guide for further details."
group.long 0x1dc++0x3
line.long 0x00 "0x01dc"
hexmask.long.word 0x00 0.--15. 1. " vc limit  ,vertical counter limit value (counts: 0,1,...vc_limit-1,vc_limit,0,1,...)"
group.long 0x1e0++0x3
line.long 0x00 "0x01e0"
hexmask.long.word 0x00 0.--15. 1. " vc start  ,window2 start for ACL gate.  See ISP guide for further details."
group.long 0x1e4++0x3
line.long 0x00 "0x01e4"
hexmask.long.word 0x00 0.--15. 1. " vc size  ,window2 size for ACL gate.  See ISP guide for further details."
rgroup.long 0x1e8++0x3
line.long 0x00 "0x01e8"
hexmask.long.word 0x00 0.--15. 1. " frame width  ,detected frame width.  Read only value."
rgroup.long 0x1ec++0x3
line.long 0x00 "0x01ec"
hexmask.long.word 0x00 0.--15. 1. " frame height  ,detected frame height.  Read only value."
group.long 0x1f0++0x3
line.long 0x00 "0x01f3"
textline "                 "
bitfld.long 0x00 31. " freeze config  , Used to freeze input port configuration.  Used when multiple register writes are required to change input port configuration. (0=normal operation, 1=hold previous input port config state)  "
hexmask.long.byte 0x00 24.--26. 1. " mode request  ,Used to stop and start input port.  See ISP guide for further details. (0=safe stop, 1=safe start, 2=urgent stop, 3=urgent start, 4=reserved4, 5=safer start, 6=reserved6, 7=reserved7)"
rgroup.long 0x1f4++0x3
line.long 0x00 "0x01f4"
hexmask.long.byte 0x00 24.--26. 1. " mode status  ,Used to monitor input port status:       bit 0: 1=running, 0=stopped, bits 1,2-reserved"
TREE.END
TREE "Frame Stats 1"
group.long 0x380++0x3
line.long 0x00 "0x0380"
textline "                 "
bitfld.long 0x00 0. " stats reset  ,   "
group.long 0x384++0x3
line.long 0x00 "0x0384"
bitfld.long 0x00 0. " stats hold  ,   "
rgroup.long 0x210++0x3
line.long 0x00 "0x0210"
hexmask.long.long 0x00 0.--31. 1. " active width min  ,"
rgroup.long 0x214++0x3
line.long 0x00 "0x0214"
hexmask.long.long 0x00 0.--31. 1. " active width max  ,"
rgroup.long 0x218++0x3
line.long 0x00 "0x0218"
hexmask.long.long 0x00 0.--31. 1. " active width sum  ,"
rgroup.long 0x21c++0x3
line.long 0x00 "0x021c"
hexmask.long.long 0x00 0.--31. 1. " active width num  ,"
rgroup.long 0x220++0x3
line.long 0x00 "0x0220"
hexmask.long.long 0x00 0.--31. 1. " active height min  ,"
rgroup.long 0x224++0x3
line.long 0x00 "0x0224"
hexmask.long.long 0x00 0.--31. 1. " active height max  ,"
rgroup.long 0x228++0x3
line.long 0x00 "0x0228"
hexmask.long.long 0x00 0.--31. 1. " active height sum  ,"
rgroup.long 0x22c++0x3
line.long 0x00 "0x022c"
hexmask.long.long 0x00 0.--31. 1. " active height num  ,"
rgroup.long 0x230++0x3
line.long 0x00 "0x0230"
hexmask.long.long 0x00 0.--31. 1. " hblank min  ,"
rgroup.long 0x234++0x3
line.long 0x00 "0x0234"
hexmask.long.long 0x00 0.--31. 1. " hblank max  ,"
rgroup.long 0x238++0x3
line.long 0x00 "0x0238"
hexmask.long.long 0x00 0.--31. 1. " hblank sum  ,"
rgroup.long 0x23c++0x3
line.long 0x00 "0x023c"
hexmask.long.long 0x00 0.--31. 1. " hblank num  ,"
rgroup.long 0x240++0x3
line.long 0x00 "0x0240"
hexmask.long.long 0x00 0.--31. 1. " vblank min  ,"
rgroup.long 0x244++0x3
line.long 0x00 "0x0244"
hexmask.long.long 0x00 0.--31. 1. " vblank max  ,"
rgroup.long 0x248++0x3
line.long 0x00 "0x0248"
hexmask.long.long 0x00 0.--31. 1. " vblank sum  ,"
rgroup.long 0x24c++0x3
line.long 0x00 "0x024c"
hexmask.long.long 0x00 0.--31. 1. " vblank num  ,"
TREE.END
TREE "Frame Stats 2"
group.long 0x380++0x3
line.long 0x00 "0x0381"
textline "                 "
bitfld.long 0x00 8. " stats reset  ,   "
group.long 0x384++0x3
line.long 0x00 "0x0385"
bitfld.long 0x00 8. " stats hold  ,   "
rgroup.long 0x290++0x3
line.long 0x00 "0x0290"
hexmask.long.long 0x00 0.--31. 1. " active width min  ,"
rgroup.long 0x294++0x3
line.long 0x00 "0x0294"
hexmask.long.long 0x00 0.--31. 1. " active width max  ,"
rgroup.long 0x298++0x3
line.long 0x00 "0x0298"
hexmask.long.long 0x00 0.--31. 1. " active width sum  ,"
rgroup.long 0x29c++0x3
line.long 0x00 "0x029c"
hexmask.long.long 0x00 0.--31. 1. " active width num  ,"
rgroup.long 0x2a0++0x3
line.long 0x00 "0x02a0"
hexmask.long.long 0x00 0.--31. 1. " active height min  ,"
rgroup.long 0x2a4++0x3
line.long 0x00 "0x02a4"
hexmask.long.long 0x00 0.--31. 1. " active height max  ,"
rgroup.long 0x2a8++0x3
line.long 0x00 "0x02a8"
hexmask.long.long 0x00 0.--31. 1. " active height sum  ,"
rgroup.long 0x2ac++0x3
line.long 0x00 "0x02ac"
hexmask.long.long 0x00 0.--31. 1. " active height num  ,"
rgroup.long 0x2b0++0x3
line.long 0x00 "0x02b0"
hexmask.long.long 0x00 0.--31. 1. " hblank min  ,"
rgroup.long 0x2b4++0x3
line.long 0x00 "0x02b4"
hexmask.long.long 0x00 0.--31. 1. " hblank max  ,"
rgroup.long 0x2b8++0x3
line.long 0x00 "0x02b8"
hexmask.long.long 0x00 0.--31. 1. " hblank sum  ,"
rgroup.long 0x2bc++0x3
line.long 0x00 "0x02bc"
hexmask.long.long 0x00 0.--31. 1. " hblank num  ,"
rgroup.long 0x2c0++0x3
line.long 0x00 "0x02c0"
hexmask.long.long 0x00 0.--31. 1. " vblank min  ,"
rgroup.long 0x2c4++0x3
line.long 0x00 "0x02c4"
hexmask.long.long 0x00 0.--31. 1. " vblank max  ,"
rgroup.long 0x2c8++0x3
line.long 0x00 "0x02c8"
hexmask.long.long 0x00 0.--31. 1. " vblank sum  ,"
rgroup.long 0x2cc++0x3
line.long 0x00 "0x02cc"
hexmask.long.long 0x00 0.--31. 1. " vblank num  ,"
TREE.END
TREE "Frame Stats 3"
group.long 0x380++0x3
line.long 0x00 "0x0382"
textline "                 "
bitfld.long 0x00 16. " stats reset  ,   "
group.long 0x384++0x3
line.long 0x00 "0x0386"
bitfld.long 0x00 16. " stats hold  ,   "
rgroup.long 0x310++0x3
line.long 0x00 "0x0310"
hexmask.long.long 0x00 0.--31. 1. " active width min  ,"
rgroup.long 0x314++0x3
line.long 0x00 "0x0314"
hexmask.long.long 0x00 0.--31. 1. " active width max  ,"
rgroup.long 0x318++0x3
line.long 0x00 "0x0318"
hexmask.long.long 0x00 0.--31. 1. " active width sum  ,"
rgroup.long 0x31c++0x3
line.long 0x00 "0x031c"
hexmask.long.long 0x00 0.--31. 1. " active width num  ,"
rgroup.long 0x320++0x3
line.long 0x00 "0x0320"
hexmask.long.long 0x00 0.--31. 1. " active height min  ,"
rgroup.long 0x324++0x3
line.long 0x00 "0x0324"
hexmask.long.long 0x00 0.--31. 1. " active height max  ,"
rgroup.long 0x328++0x3
line.long 0x00 "0x0328"
hexmask.long.long 0x00 0.--31. 1. " active height sum  ,"
rgroup.long 0x32c++0x3
line.long 0x00 "0x032c"
hexmask.long.long 0x00 0.--31. 1. " active height num  ,"
rgroup.long 0x330++0x3
line.long 0x00 "0x0330"
hexmask.long.long 0x00 0.--31. 1. " hblank min  ,"
rgroup.long 0x334++0x3
line.long 0x00 "0x0334"
hexmask.long.long 0x00 0.--31. 1. " hblank max  ,"
rgroup.long 0x338++0x3
line.long 0x00 "0x0338"
hexmask.long.long 0x00 0.--31. 1. " hblank sum  ,"
rgroup.long 0x33c++0x3
line.long 0x00 "0x033c"
hexmask.long.long 0x00 0.--31. 1. " hblank num  ,"
rgroup.long 0x340++0x3
line.long 0x00 "0x0340"
hexmask.long.long 0x00 0.--31. 1. " vblank min  ,"
rgroup.long 0x344++0x3
line.long 0x00 "0x0344"
hexmask.long.long 0x00 0.--31. 1. " vblank max  ,"
rgroup.long 0x348++0x3
line.long 0x00 "0x0348"
hexmask.long.long 0x00 0.--31. 1. " vblank sum  ,"
rgroup.long 0x34c++0x3
line.long 0x00 "0x034c"
hexmask.long.long 0x00 0.--31. 1. " vblank num  ,"
TREE.END
TREE "Frame Stats 4"
group.long 0x380++0x3
line.long 0x00 "0x0383"
textline "                 "
bitfld.long 0x00 24. " stats reset  ,   "
group.long 0x384++0x3
line.long 0x00 "0x0387"
bitfld.long 0x00 24. " stats hold  ,   "
rgroup.long 0x390++0x3
line.long 0x00 "0x0390"
hexmask.long.long 0x00 0.--31. 1. " active width min  ,"
rgroup.long 0x394++0x3
line.long 0x00 "0x0394"
hexmask.long.long 0x00 0.--31. 1. " active width max  ,"
rgroup.long 0x398++0x3
line.long 0x00 "0x0398"
hexmask.long.long 0x00 0.--31. 1. " active width sum  ,"
rgroup.long 0x39c++0x3
line.long 0x00 "0x039c"
hexmask.long.long 0x00 0.--31. 1. " active width num  ,"
rgroup.long 0x3a0++0x3
line.long 0x00 "0x03a0"
hexmask.long.long 0x00 0.--31. 1. " active height min  ,"
rgroup.long 0x3a4++0x3
line.long 0x00 "0x03a4"
hexmask.long.long 0x00 0.--31. 1. " active height max  ,"
rgroup.long 0x3a8++0x3
line.long 0x00 "0x03a8"
hexmask.long.long 0x00 0.--31. 1. " active height sum  ,"
rgroup.long 0x3ac++0x3
line.long 0x00 "0x03ac"
hexmask.long.long 0x00 0.--31. 1. " active height num  ,"
rgroup.long 0x3b0++0x3
line.long 0x00 "0x03b0"
hexmask.long.long 0x00 0.--31. 1. " hblank min  ,"
rgroup.long 0x3b4++0x3
line.long 0x00 "0x03b4"
hexmask.long.long 0x00 0.--31. 1. " hblank max  ,"
rgroup.long 0x3b8++0x3
line.long 0x00 "0x03b8"
hexmask.long.long 0x00 0.--31. 1. " hblank sum  ,"
rgroup.long 0x3bc++0x3
line.long 0x00 "0x03bc"
hexmask.long.long 0x00 0.--31. 1. " hblank num  ,"
rgroup.long 0x3c0++0x3
line.long 0x00 "0x03c0"
hexmask.long.long 0x00 0.--31. 1. " vblank min  ,"
rgroup.long 0x3c4++0x3
line.long 0x00 "0x03c4"
hexmask.long.long 0x00 0.--31. 1. " vblank max  ,"
rgroup.long 0x3c8++0x3
line.long 0x00 "0x03c8"
hexmask.long.long 0x00 0.--31. 1. " vblank sum  ,"
rgroup.long 0x3cc++0x3
line.long 0x00 "0x03cc"
hexmask.long.long 0x00 0.--31. 1. " vblank num  ,"
TREE.END
TREE "Stream crossbar"
group.long 0x3e0++0x3
line.long 0x00 "0x03e0"
hexmask.long.byte 0x00 0.--1. 1. " Stream1 select  ,Select the mode for the MCFE input 1 (0=Off, 1=Select data from one input., 2=Select data from one input and filter by ID., 3=Reserved 3)"
hexmask.long.byte 0x00 8.--9. 1. " Stream1 source  ,Select the stream source for the MCFE input 1 (when Stream 1 select is 1 or 2) (0=Video port 1, 1=Video port 2, 2=Video port 3, 3=Video port 4)"
hexmask.long.byte 0x00 16.--18. 1. " Stream1 id  ,Stream ID to match for the MCFE input 1 (when Stream 1 select is 2)"
group.long 0x3e4++0x3
line.long 0x00 "0x03e4"
hexmask.long.byte 0x00 0.--1. 1. " Stream2 select  ,Select the mode for the MCFE input 2 (0=Off, 1=Select data from one input., 2=Select data from one input and filter by ID., 3=Reserved 3)"
hexmask.long.byte 0x00 8.--9. 1. " Stream2 source  ,Select the stream source for the MCFE input 2 (when Stream 2 select is 1 or 2) (0=Video port 1, 1=Video port 2, 2=Video port 3, 3=Video port 4)"
hexmask.long.byte 0x00 16.--18. 1. " Stream2 id  ,Stream ID to match for the MCFE input 2 (when Stream 2 select is 2)"
group.long 0x3e8++0x3
line.long 0x00 "0x03e8"
hexmask.long.byte 0x00 0.--1. 1. " Stream3 select  ,Select the mode for the MCFE input 3 (0=Off, 1=Select data from one input., 2=Select data from one input and filter by ID., 3=Reserved 3)"
hexmask.long.byte 0x00 8.--9. 1. " Stream3 source  ,Select the stream source for the MCFE input 3 (when Stream 3 select is 1 or 2) (0=Video port 1, 1=Video port 2, 2=Video port 3, 3=Video port 4)"
hexmask.long.byte 0x00 16.--18. 1. " Stream3 id  ,Stream ID to match for the MCFE input 3 (when Stream 3 select is 2)"
group.long 0x3ec++0x3
line.long 0x00 "0x03ec"
hexmask.long.byte 0x00 0.--1. 1. " Stream4 select  ,Select the mode for the MCFE input 4 (0=Off, 1=Select data from one input., 2=Select data from one input and filter by ID., 3=Reserved 3)"
hexmask.long.byte 0x00 8.--9. 1. " Stream4 source  ,Select the stream source for the MCFE input 4 (when Stream 4 select is 1 or 2) (0=Video port 1, 1=Video port 2, 2=Video port 3, 3=Video port 4)"
hexmask.long.byte 0x00 16.--18. 1. " Stream4 id  ,Stream ID to match for the MCFE input 4 (when Stream 4 select is 2)"
TREE.END
TREE "Multichannel frontend"
group.long 0x400++0x3
line.long 0x00 "0x0400"
hexmask.long.byte 0x00 0.--1. 1. " FIFO In configuration  ,"
hexmask.long.byte 0x00 8.--9. 1. " FIFO Out configuration  ,"
group.long 0x404++0x3
line.long 0x00 "0x0404"
hexmask.long.word 0x00 0.--15. 1. " FIFO1 low watermark  ,"
hexmask.long.word 0x00 16.--31. 1. " FIFO1 high watermark  ,"
group.long 0x408++0x3
line.long 0x00 "0x0408"
hexmask.long.word 0x00 0.--15. 1. " FIFO2 low watermark  ,"
hexmask.long.word 0x00 16.--31. 1. " FIFO2 high watermark  ,"
group.long 0x40c++0x3
line.long 0x00 "0x040c"
hexmask.long.word 0x00 0.--15. 1. " FIFO3 low watermark  ,"
hexmask.long.word 0x00 16.--31. 1. " FIFO3 high watermark  ,"
group.long 0x410++0x3
line.long 0x00 "0x0410"
hexmask.long.word 0x00 0.--15. 1. " FIFO4 low watermark  ,"
hexmask.long.word 0x00 16.--31. 1. " FIFO4 high watermark  ,"
group.long 0x414++0x3
line.long 0x00 "0x0414"
hexmask.long.byte 0x00 0.--3. 1. " Scheduler mode  ,Predefined operation modes (0=Stopped, 1=Manual scheduling, 2=Single stream on first input, 3=Dual stream (FIFO only), 4=Dual stream (frame buffer), 5=Triple stream (first through frame buffer, second through FIFO, third direct), 6=Quad stream (first and second through frame buffer, third through FIFO, fourth direct), 7=Single stream DOL, configuraton is defined by input_mode (valid input_modes 0..2), 8=Two sensors TDMF flex schedule, 9=Two 2x DOL sensors TDMF flex schedule, 10=Three sensors TDMF flex schedule, 11=Four sensors TDMF flex schedule, 12=Two sensors TDMF fix schedule, 13=Two 2x DOL sensors TDMF fix schedule, 14=Three sensors TDMF fix schedule, 15=Four sensors TDMF fix schedule)"
hexmask.long.byte 0x00 16.--19. 1. " Start slot  ,0x0F - IDLE (normal state)             0..5 - slot to trigger in SRAM source mode. Only transition from 0xF is counted as an event"
rgroup.long 0x418++0x3
line.long 0x00 "0x0418"
hexmask.long.byte 0x00 0.--3. 1. " Current slot  ,"
hexmask.long.byte 0x00 8.--11. 1. " Scheduler status  ,"
rgroup.long 0x41c++0x4
line.long 0x00 "0x041c"
hexmask.long.byte 0x0 0.--5. 1. " Output writer last ID[0]  , "
hexmask.long.byte 0x0 8.--13. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--21. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--29. 1. "  [3]  , "
group.long 0x420++0xa
line.quad 0x00 "0x0420"
hexmask.long.byte 0x0 0.--3. 1. " Slot mode[0]              , "
hexmask.long.byte 0x0 8.--11. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--19. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--27. 1. "  [3]  , "
hexmask.word.byte 0x4 0.--3. 1. "  [4]  , "
hexmask.word.byte 0x4 8.--11. 1. "  [5]  , "
rgroup.long 0x428++0xa
line.quad 0x00 "0x0428"
hexmask.long.byte 0x0 0.--3. 1. " Slot status[0]            , "
hexmask.long.byte 0x0 8.--11. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--19. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--27. 1. "  [3]  , "
hexmask.word.byte 0x4 0.--3. 1. "  [4]  , "
hexmask.word.byte 0x4 8.--11. 1. "  [5]  , "
group.long 0x430++0xa
line.quad 0x00 "0x0430"
hexmask.long.byte 0x0 0.--7. 1. " Slot event[0]             , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.word.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.word.byte 0x4 8.--15. 1. "  [5]  , "
group.long 0x438++0x18
line.long 0x00 "0x0438"
hexmask.long.long 0x0 0.--31. 1. " Slot delay[0]             ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
hexmask.long.long 0x10 0.--31. 1. " [4] , "
hexmask.long.long 0x14 0.--31. 1. " [5] , "
group.long 0x458++0xa
line.quad 0x00 "0x0458"
hexmask.long.byte 0x0 0.--0. 1. " Slot cfg valid[0]         , "
hexmask.long.byte 0x0 8.--8. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--16. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--24. 1. "  [3]  , "
hexmask.word.byte 0x4 0.--0. 1. "  [4]  , "
hexmask.word.byte 0x4 8.--8. 1. "  [5]  , "
group.long 0x460++0x18
line.long 0x00 "0x0460"
hexmask.long.long 0x0 0.--31. 1. " Slot cfg base[0]          ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
hexmask.long.long 0x10 0.--31. 1. " [4] , "
hexmask.long.long 0x14 0.--31. 1. " [5] , "
group.long 0x480++0x18
line.long 0x00 "0x0480"
hexmask.long.long 0x0 0.--31. 1. " Slot cfg size[0]          ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
hexmask.long.long 0x10 0.--31. 1. " [4] , "
hexmask.long.long 0x14 0.--31. 1. " [5] , "
group.long 0x4a0++0x18
line.long 0x00 "0x04a0"
hexmask.long.long 0x0 0.--31. 1. " Slot cfg read units[0]    ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
hexmask.long.long 0x10 0.--31. 1. " [4] , "
hexmask.long.long 0x14 0.--31. 1. " [5] , "
group.long 0x4c0++0x18
line.long 0x00 "0x04c0"
hexmask.long.long 0x0 0.--31. 1. " Slot cfg write units[0]   ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
hexmask.long.long 0x10 0.--31. 1. " [4] , "
hexmask.long.long 0x14 0.--31. 1. " [5] , "
group.long 0x4e0++0x1a
line.quad 0x00 "0x04e0"
hexmask.long.byte 0x0 0.--5. 1. " Slot inputs[0|0]          , "
hexmask.long.byte 0x0 8.--13. 1. "  [1|0] , "
hexmask.long.byte 0x0 16.--21. 1. "  [2|0] , "
hexmask.long.byte 0x0 24.--29. 1. "  [3|0] , "
hexmask.long.byte 0x4 0.--5. 1. "  [4|0] , "
hexmask.long.byte 0x4 8.--13. 1. "  [5|0] , "
line.quad 0x06 "0x04e6"
hexmask.long.byte 0x4 16.--21. 1. " Slot inputs[0|1]          , "
hexmask.long.byte 0x4 24.--29. 1. "  [1|1] , "
hexmask.long.byte 0x8 0.--5. 1. "  [2|1] , "
hexmask.long.byte 0x8 8.--13. 1. "  [3|1] , "
hexmask.long.byte 0x8 16.--21. 1. "  [4|1] , "
hexmask.long.byte 0x8 24.--29. 1. "  [5|1] , "
line.quad 0x0c "0x04ec"
hexmask.long.byte 0xc 0.--5. 1. " Slot inputs[0|2]          , "
hexmask.long.byte 0xc 8.--13. 1. "  [1|2] , "
hexmask.long.byte 0xc 16.--21. 1. "  [2|2] , "
hexmask.long.byte 0xc 24.--29. 1. "  [3|2] , "
hexmask.long.byte 0x10 0.--5. 1. "  [4|2] , "
hexmask.long.byte 0x10 8.--13. 1. "  [5|2] , "
line.quad 0x12 "0x04f2"
hexmask.long.byte 0x10 16.--21. 1. " Slot inputs[0|3]          , "
hexmask.long.byte 0x10 24.--29. 1. "  [1|3] , "
hexmask.long.byte 0x14 0.--5. 1. "  [2|3] , "
hexmask.long.byte 0x14 8.--13. 1. "  [3|3] , "
hexmask.long.byte 0x14 16.--21. 1. "  [4|3] , "
hexmask.long.byte 0x14 24.--29. 1. "  [5|3] , "
group.long 0x500++0x1a
line.quad 0x00 "0x0500"
hexmask.long.byte 0x0 0.--5. 1. " Slot outputs buffer1[0|0] , "
hexmask.long.byte 0x0 8.--13. 1. "  [1|0] , "
hexmask.long.byte 0x0 16.--21. 1. "  [2|0] , "
hexmask.long.byte 0x0 24.--29. 1. "  [3|0] , "
hexmask.long.byte 0x4 0.--5. 1. "  [4|0] , "
hexmask.long.byte 0x4 8.--13. 1. "  [5|0] , "
line.quad 0x06 "0x0506"
hexmask.long.byte 0x4 16.--21. 1. " Slot outputs buffer1[0|1] , "
hexmask.long.byte 0x4 24.--29. 1. "  [1|1] , "
hexmask.long.byte 0x8 0.--5. 1. "  [2|1] , "
hexmask.long.byte 0x8 8.--13. 1. "  [3|1] , "
hexmask.long.byte 0x8 16.--21. 1. "  [4|1] , "
hexmask.long.byte 0x8 24.--29. 1. "  [5|1] , "
line.quad 0x0c "0x050c"
hexmask.long.byte 0xc 0.--5. 1. " Slot outputs buffer1[0|2] , "
hexmask.long.byte 0xc 8.--13. 1. "  [1|2] , "
hexmask.long.byte 0xc 16.--21. 1. "  [2|2] , "
hexmask.long.byte 0xc 24.--29. 1. "  [3|2] , "
hexmask.long.byte 0x10 0.--5. 1. "  [4|2] , "
hexmask.long.byte 0x10 8.--13. 1. "  [5|2] , "
line.quad 0x12 "0x0512"
hexmask.long.byte 0x10 16.--21. 1. " Slot outputs buffer1[0|3] , "
hexmask.long.byte 0x10 24.--29. 1. "  [1|3] , "
hexmask.long.byte 0x14 0.--5. 1. "  [2|3] , "
hexmask.long.byte 0x14 8.--13. 1. "  [3|3] , "
hexmask.long.byte 0x14 16.--21. 1. "  [4|3] , "
hexmask.long.byte 0x14 24.--29. 1. "  [5|3] , "
group.long 0x520++0x1a
line.quad 0x00 "0x0520"
hexmask.long.byte 0x0 0.--5. 1. " Slot outputs buffer2[0|0] , "
hexmask.long.byte 0x0 8.--13. 1. "  [1|0] , "
hexmask.long.byte 0x0 16.--21. 1. "  [2|0] , "
hexmask.long.byte 0x0 24.--29. 1. "  [3|0] , "
hexmask.long.byte 0x4 0.--5. 1. "  [4|0] , "
hexmask.long.byte 0x4 8.--13. 1. "  [5|0] , "
line.quad 0x06 "0x0526"
hexmask.long.byte 0x4 16.--21. 1. " Slot outputs buffer2[0|1] , "
hexmask.long.byte 0x4 24.--29. 1. "  [1|1] , "
hexmask.long.byte 0x8 0.--5. 1. "  [2|1] , "
hexmask.long.byte 0x8 8.--13. 1. "  [3|1] , "
hexmask.long.byte 0x8 16.--21. 1. "  [4|1] , "
hexmask.long.byte 0x8 24.--29. 1. "  [5|1] , "
line.quad 0x0c "0x052c"
hexmask.long.byte 0xc 0.--5. 1. " Slot outputs buffer2[0|2] , "
hexmask.long.byte 0xc 8.--13. 1. "  [1|2] , "
hexmask.long.byte 0xc 16.--21. 1. "  [2|2] , "
hexmask.long.byte 0xc 24.--29. 1. "  [3|2] , "
hexmask.long.byte 0x10 0.--5. 1. "  [4|2] , "
hexmask.long.byte 0x10 8.--13. 1. "  [5|2] , "
line.quad 0x12 "0x0532"
hexmask.long.byte 0x10 16.--21. 1. " Slot outputs buffer2[0|3] , "
hexmask.long.byte 0x10 24.--29. 1. "  [1|3] , "
hexmask.long.byte 0x14 0.--5. 1. "  [2|3] , "
hexmask.long.byte 0x14 8.--13. 1. "  [3|3] , "
hexmask.long.byte 0x14 16.--21. 1. "  [4|3] , "
hexmask.long.byte 0x14 24.--29. 1. "  [5|3] , "
rgroup.long 0x53c++0x4
line.long 0x00 "0x053c"
hexmask.long.byte 0x0 0.--5. 1. " Input writer last ID[0]   , "
hexmask.long.byte 0x0 8.--13. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--21. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--29. 1. "  [3]  , "
group.long 0x540++0x4
line.long 0x00 "0x0540"
hexmask.long.byte 0x0 0.--1. 1. " Input mode[0]             , "
hexmask.long.byte 0x0 8.--9. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--17. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--25. 1. "  [3]  , "
group.long 0x544++0x4
line.long 0x00 "0x0544"
hexmask.long.byte 0x0 0.--0. 1. " Input msb align[0]        , "
hexmask.long.byte 0x0 8.--8. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--16. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--24. 1. "  [3]  , "
rgroup.long 0x548++0x4
line.long 0x00 "0x0548"
hexmask.long.byte 0x0 0.--3. 1. " Input status[0]           , "
hexmask.long.byte 0x0 8.--11. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--19. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--27. 1. "  [3]  , "
group.long 0x54c++0x4
line.long 0x00 "0x054c"
hexmask.long.byte 0x0 0.--7. 1. " Input data width[0]       , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
group.long 0x550++0x4
line.long 0x00 "0x0550"
hexmask.long.byte 0x0 0.--0. 1. " Input stat valid[0]       , "
hexmask.long.byte 0x0 8.--8. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--16. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--24. 1. "  [3]  , "
group.long 0x554++0x10
line.long 0x00 "0x0554"
hexmask.long.long 0x0 0.--31. 1. " Input stat base[0]        ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
group.long 0x564++0x10
line.long 0x00 "0x0564"
hexmask.long.long 0x0 0.--31. 1. " Input stat size[0]        ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
group.long 0x574++0x10
line.long 0x00 "0x0574"
hexmask.long.long 0x0 0.--31. 1. " Input stat read units[0]  ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
group.long 0x584++0x4
line.long 0x00 "0x0584"
hexmask.long.byte 0x0 0.--5. 1. " Input write buffer1[0]    , "
hexmask.long.byte 0x0 8.--13. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--21. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--29. 1. "  [3]  , "
group.long 0x588++0x4
line.long 0x00 "0x0588"
hexmask.long.byte 0x0 0.--5. 1. " Input write buffer2[0]    , "
hexmask.long.byte 0x0 8.--13. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--21. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--29. 1. "  [3]  , "
group.long 0x58c++0x3
line.long 0x00 "0x058c"
hexmask.long.word 0x00 0.--12. 1. " Output HBlank  ,Minimal horizontal blanking at the MCFE output."
group.long 0x590++0x3
line.long 0x00 "0x0590"
hexmask.long.byte 0x00 0.--5. 1. " CDMA read FIFO watermark  ,Config DMA: Number of words space in FIFO before AXI read burst(s) start (legal values = max_burst_length(max_arlen+1) to 2**fifo_aw, but workable value for your system are probably less!). Allowing n back to back bursts to generated if watermark is set to n*burst length. Burst(s) continue while FIFO has enough space for next burst."
hexmask.long.byte 0x00 16.--19. 1. " CDMA max arlen  ,Config DMA: Max value to use for arlen (axi burst length). 0000= max 1 transfer/burst, upto 1111= max 16 transfers/burst"
group.long 0x594++0x3
line.long 0x00 "0x0594"
hexmask.long.byte 0x00 0.--7. 1. " CDMA rxact maxostand  ,Config DMA: Max outstanding read transactions (bursts) allowed. Zero means no maximum (uses internal limit of 2048)."
hexmask.long.byte 0x00 8.--15. 1. " CDMA armaxwait limit  ,Config DMA: arvalid maxwait limit(cycles) to raise axi_fail_armaxwait alarm. Zero disables alarm raise"
hexmask.long.byte 0x00 16.--23. 1. " CDMA rxnfr ostand limit  ,Config DMA: The number of outstanding read data transfers(responses..1 per transfer) to raise axi_fail_rxnfr_ostand alarm"
group.long 0x598++0x3
line.long 0x00 "0x0598"
hexmask.long.byte 0x00 0.--5. 1. " CDMA write FIFO watermark  ,Config DMA: Number of words in FIFO before AXI write burst(s) start (legal values = max_burst_length(max_awlen+1) to 2**fifo_aw, but workable value for your system are probably less!). Allowing n back to back bursts to generated if watermark is set to n*burst length. Burst(s) continue while FIFO has enough for next burst"
hexmask.long.byte 0x00 16.--19. 1. " CDMA max awlen  ,Config DMA: Max value to use for awlen (axi burst length). 0000= max 1 transfer/burst, upto 1111= max 16 transfers/burst."
group.long 0x5a0++0x3
line.long 0x00 "0x05a0"
hexmask.long.byte 0x00 0.--7. 1. " CDMA wxact maxostand  ,Config DMA: Max outstanding write transactions (bursts) allowed. Zero means no maximum(uses internal limit of 2048)."
hexmask.long.byte 0x00 8.--15. 1. " CDMA awmaxwait limit  ,Config DMA: awvalid maxwait limit(cycles) to raise axi_fail_awmaxwait alarm. Zero disables alarm raise"
hexmask.long.byte 0x00 16.--23. 1. " CDMA wmaxwait limit  ,Config DMA: wvalid maxwait limit(cycles) to raise axi_fail_wmaxwait alarm. Zero disables alarm raise"
hexmask.long.byte 0x00 24.--31. 1. " CDMA wxact ostand limit  ,Config DMA: Number oustsanding write transactions(bursts)(responses..1 per burst) limit to raise axi_fail_wxact_ostand. Zero disables alarm raise"
group.long 0x5a4++0x3
line.long 0x00 "0x05a4"
hexmask.long.byte 0x00 0.--6. 1. " WDMA FIFO watermark  ,Frame writer DMA: Number of words in FIFO before AXI write burst(s) start (legal values = max_burst_length(max_awlen+1) to 2**fifo_aw, but workable value for your system are probably less!). Allowing n back to back bursts to generated if watermark is set to n*burst length. Burst(s) continue while FIFO has enough for next burst"
hexmask.long.byte 0x00 16.--19. 1. " WDMA max awlen  ,Frame writer DMA: Max value to use for awlen (axi burst length). 0000= max 1 transfer/burst, upto 1111= max 16 transfers/burst."
group.long 0x5a8++0x3
line.long 0x00 "0x05a8"
hexmask.long.byte 0x00 0.--7. 1. " WDMA wxact maxostand  ,Frame writer DMA: Max outstanding write transactions (bursts) allowed. Zero means no maximum(uses internal limit of 2048)."
hexmask.long.byte 0x00 8.--15. 1. " WDMA awmaxwait limit  ,Frame writer DMA: awvalid maxwait limit(cycles) to raise axi_fail_awmaxwait alarm. Zero disables alarm raise"
hexmask.long.byte 0x00 16.--23. 1. " WDMA wmaxwait limit  ,Frame writer DMA: wvalid maxwait limit(cycles) to raise axi_fail_wmaxwait alarm. Zero disables alarm raise"
hexmask.long.byte 0x00 24.--31. 1. " WDMA wxact ostand limit  ,Frame writer DMA: Number oustsanding write transactions(bursts)(responses..1 per burst) limit to raise axi_fail_wxact_ostand. Zero disables alarm raise"
group.long 0x5ac++0x3
line.long 0x00 "0x05ac"
hexmask.long.byte 0x00 0.--6. 1. " RDMA FIFO watermark  ,Read DMA: Number of words space in FIFO before AXI read burst(s) start (legal values = max_burst_length(max_arlen+1) to 2**fifo_aw, but the workable value for your system is probably less.) Allowing n back to back bursts to generated if watermark is set to n*burst length. Burst(s) continue while FIFO has enough space for next burst."
hexmask.long.byte 0x00 16.--19. 1. " RDMA max arlen  ,Read DMA: Max value to use for arlen (axi burst length). 0000= max 1 transfer/burst , upto 1111= max 16 transfers/burst"
group.long 0x5b0++0x3
line.long 0x00 "0x05b0"
hexmask.long.byte 0x00 0.--7. 1. " RDMA rxact maxostand  ,Read DMA: Max outstanding read transactions (bursts) allowed. Zero means no maximum(uses internal limit of 2048)."
hexmask.long.byte 0x00 8.--15. 1. " RDMA armaxwait limit  ,Read DMA: arvalid maxwait limit(cycles) to raise axi_fail_armaxwait alarm. Zero disables alarm raise"
hexmask.long.byte 0x00 16.--23. 1. " RDMA rxnfr ostand limit  ,Read DMA: The number of outstanding read data transfers(responses..1 per transfer) to raise axi_fail_rxnfr_ostand alarm"
TREE.END
TREE "Multichannel backend"
group.long 0x5c0++0x3
line.long 0x00 "0x05c0"
hexmask.long.byte 0x00 0.--6. 1. " WDMA FIFO watermark  ,Output DMA: Number of words in FIFO before AXI write burst(s) start (legal values = max_burst_length(max_awlen+1) to 2**fifo_aw, but workable value for your system is probably less.) Allowing n back to back bursts to be generated if watermark is set to n*burst length. Burst(s) continue while FIFO has enough for next burst"
hexmask.long.byte 0x00 16.--19. 1. " WDMA max awlen  ,Output DMA: Max value to use for awlen (axi burst length). 0000= max 1 transfer/burst , upto 1111= max 16 transfers/burst."
group.long 0x5c4++0x3
line.long 0x00 "0x05c4"
hexmask.long.byte 0x00 0.--7. 1. " WDMA wxact maxostand  ,Output DMA: Max outstanding write transactions (bursts) allowed. Zero means no maximum(uses internal limit of 2048)."
hexmask.long.byte 0x00 8.--15. 1. " WDMA awmaxwait limit  ,Output DMA: awvalid maxwait limit(cycles) to raise axi_fail_awmaxwait alarm. Zero disables alarm raise"
hexmask.long.byte 0x00 16.--23. 1. " WDMA wmaxwait limit  ,Output DMA: wvalid maxwait limit(cycles) to raise axi_fail_wmaxwait alarm. Zero disables alarm raise"
hexmask.long.byte 0x00 24.--31. 1. " WDMA wxact ostand limit  ,Output DMA: Number oustsanding write transactions(bursts)(responses..1 per burst) limit to raise axi_fail_wxact_ostand. Zero disables alarm raise"
group.long 0x5c8++0x3
line.long 0x00 "0x05c8"
textline "                 "
bitfld.long 0x00 0. " Enable flow control  ,   "
group.long 0x5cc++0x3
line.long 0x00 "0x05cc"
hexmask.long.byte 0x00 0.--7. 1. " Fifo1 watermark  ,"
hexmask.long.byte 0x00 16.--23. 1. " Fifo2 watermark  ,"
group.long 0x5d0++0x3
line.long 0x00 "0x05d0"
hexmask.long.byte 0x00 0.--7. 1. " Fifo3 watermark  ,"
hexmask.long.byte 0x00 16.--23. 1. " Fifo4 watermark  ,"
TREE.END
TREE "Pipeline frontend"
group.long 0xc++0x3
line.long 0x00 "0x000c"
textline "                 "
bitfld.long 0x00 0. " Enable config lock  , Enable clock cross locking of the configuration updates  "
bitfld.long 0x00 1. " Disable MCFE  , Disable multichannel frontend  "
bitfld.long 0x00 2. " Bypass MCFE  , Bypass multichannel frontend  "
bitfld.long 0x00 3. " Position Video test gen  , Video test generator position (0=After MCFE, 1=After Input ports)  "
group.long 0x10++0x3
line.long 0x00 "0x0010"
hexmask.long.byte 0x00 0.--1. 1. " Histogram1 switch  ,Location of the channel 1 histogram (0=Sensor input 1 MSB, 1=Sensor input 1 LSB, 2=ISP data 1, 3=Off)"
group.long 0x14++0x3
line.long 0x00 "0x0014"
hexmask.long.byte 0x00 0.--1. 1. " Histogram2 switch  ,Location of the channel 2 histogram (0=Sensor input 2 MSB, 1=Sensor input 2 LSB, 2=ISP data 2, 3=Off)"
group.long 0x18++0x3
line.long 0x00 "0x0018"
hexmask.long.byte 0x00 0.--1. 1. " Histogram3 switch  ,Location of the channel 3 histogram (0=Sensor input 3 MSB, 1=Sensor input 3 LSB, 2=ISP data 3, 3=Off)"
group.long 0x1c++0x3
line.long 0x00 "0x001c"
hexmask.long.byte 0x00 0.--1. 1. " Histogram4 switch  ,Location of the channel 4 histogram (0=Sensor input 4 MSB, 1=Sensor input 4 LSB, 2=ISP data 4, 3=Off)"
group.long 0x20++0x3
line.long 0x00 "0x0020"
textline "                 "
bitfld.long 0x00 0. " Global FSM reset  , Reset of state machines (0=Normal operation, 1=Synchronous reset of FSMs in design (faster recovery after broken frame))  "
TREE.END
TREE "Frame Check sensor 1"
group.long 0x600++0x3
line.long 0x00 "0x0600"
textline "                 "
bitfld.long 0x00 0. " Manual trigger  , Manual triggering of the fault  "
bitfld.long 0x00 1. " Field mode  , 0=pulse; 1=edge  "
group.long 0x604++0x3
line.long 0x00 "0x0604"
hexmask.long.long 0x00 0.--31. 1. " Active width  ,Expected active width"
group.long 0x608++0x3
line.long 0x00 "0x0608"
hexmask.long.long 0x00 0.--31. 1. " Active height  ,Expected active height"
group.long 0x60c++0x3
line.long 0x00 "0x060c"
hexmask.long.long 0x00 0.--31. 1. " Hblank min  ,Expected minimal horizontal blank"
group.long 0x610++0x3
line.long 0x00 "0x0610"
hexmask.long.long 0x00 0.--31. 1. " Hblank max  ,Expected maximal horizontal blank"
group.long 0x614++0x3
line.long 0x00 "0x0614"
hexmask.long.long 0x00 0.--31. 1. " Vblank min  ,Expected minimal vertical blank"
group.long 0x618++0x3
line.long 0x00 "0x0618"
hexmask.long.long 0x00 0.--31. 1. " Vblank max  ,Expected maximal vertical blank"
TREE.END
TREE "Frame Check sensor 2"
group.long 0x620++0x3
line.long 0x00 "0x0620"
textline "                 "
bitfld.long 0x00 0. " Manual trigger  , Manual triggering of the fault  "
bitfld.long 0x00 1. " Field mode  , 0=pulse; 1=edge  "
group.long 0x624++0x3
line.long 0x00 "0x0624"
hexmask.long.long 0x00 0.--31. 1. " Active width  ,Expected active width"
group.long 0x628++0x3
line.long 0x00 "0x0628"
hexmask.long.long 0x00 0.--31. 1. " Active height  ,Expected active height"
group.long 0x62c++0x3
line.long 0x00 "0x062c"
hexmask.long.long 0x00 0.--31. 1. " Hblank min  ,Expected minimal horizontal blank"
group.long 0x630++0x3
line.long 0x00 "0x0630"
hexmask.long.long 0x00 0.--31. 1. " Hblank max  ,Expected maximal horizontal blank"
group.long 0x634++0x3
line.long 0x00 "0x0634"
hexmask.long.long 0x00 0.--31. 1. " Vblank min  ,Expected minimal vertical blank"
group.long 0x638++0x3
line.long 0x00 "0x0638"
hexmask.long.long 0x00 0.--31. 1. " Vblank max  ,Expected maximal vertical blank"
TREE.END
TREE "Frame Check sensor 3"
group.long 0x640++0x3
line.long 0x00 "0x0640"
textline "                 "
bitfld.long 0x00 0. " Manual trigger  , Manual triggering of the fault  "
bitfld.long 0x00 1. " Field mode  , 0=pulse; 1=edge  "
group.long 0x644++0x3
line.long 0x00 "0x0644"
hexmask.long.long 0x00 0.--31. 1. " Active width  ,Expected active width"
group.long 0x648++0x3
line.long 0x00 "0x0648"
hexmask.long.long 0x00 0.--31. 1. " Active height  ,Expected active height"
group.long 0x64c++0x3
line.long 0x00 "0x064c"
hexmask.long.long 0x00 0.--31. 1. " Hblank min  ,Expected minimal horizontal blank"
group.long 0x650++0x3
line.long 0x00 "0x0650"
hexmask.long.long 0x00 0.--31. 1. " Hblank max  ,Expected maximal horizontal blank"
group.long 0x654++0x3
line.long 0x00 "0x0654"
hexmask.long.long 0x00 0.--31. 1. " Vblank min  ,Expected minimal vertical blank"
group.long 0x658++0x3
line.long 0x00 "0x0658"
hexmask.long.long 0x00 0.--31. 1. " Vblank max  ,Expected maximal vertical blank"
TREE.END
TREE "Frame Check sensor 4"
group.long 0x660++0x3
line.long 0x00 "0x0660"
textline "                 "
bitfld.long 0x00 0. " Manual trigger  , Manual triggering of the fault  "
bitfld.long 0x00 1. " Field mode  , 0=pulse; 1=edge  "
group.long 0x664++0x3
line.long 0x00 "0x0664"
hexmask.long.long 0x00 0.--31. 1. " Active width  ,Expected active width"
group.long 0x668++0x3
line.long 0x00 "0x0668"
hexmask.long.long 0x00 0.--31. 1. " Active height  ,Expected active height"
group.long 0x66c++0x3
line.long 0x00 "0x066c"
hexmask.long.long 0x00 0.--31. 1. " Hblank min  ,Expected minimal horizontal blank"
group.long 0x670++0x3
line.long 0x00 "0x0670"
hexmask.long.long 0x00 0.--31. 1. " Hblank max  ,Expected maximal horizontal blank"
group.long 0x674++0x3
line.long 0x00 "0x0674"
hexmask.long.long 0x00 0.--31. 1. " Vblank min  ,Expected minimal vertical blank"
group.long 0x678++0x3
line.long 0x00 "0x0678"
hexmask.long.long 0x00 0.--31. 1. " Vblank max  ,Expected maximal vertical blank"
TREE.END
TREE "Frame counter sensor control"
group.long 0x680++0x3
line.long 0x00 "0x0680"
textline "                 "
bitfld.long 0x00 0. " Stat hold  , Hold the statistics for atomic read  "
bitfld.long 0x00 1. " Stat reset  , 1 - clear the counter  "
TREE.END
TREE "Frame counter ISP control"
group.long 0x680++0x3
line.long 0x00 "0x0680"
textline "                 "
bitfld.long 0x00 2. " Stat hold  , Hold the statistics for atomic read  "
bitfld.long 0x00 3. " Stat reset  , 1 - clear the counter  "
TREE.END
TREE "Frame counter sensor 1"
group.long 0x684++0x3
line.long 0x00 "0x0684"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter sensor 2"
group.long 0x688++0x3
line.long 0x00 "0x0688"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter sensor 3"
group.long 0x68c++0x3
line.long 0x00 "0x068c"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter sensor 4"
group.long 0x690++0x3
line.long 0x00 "0x0690"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP start"
group.long 0x694++0x3
line.long 0x00 "0x0694"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP VTPG"
group.long 0x698++0x3
line.long 0x00 "0x0698"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP Iridix"
group.long 0x69c++0x3
line.long 0x00 "0x069c"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP Demosaic"
group.long 0x6a0++0x3
line.long 0x00 "0x06a0"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP out 1"
group.long 0x6a4++0x3
line.long 0x00 "0x06a4"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP out 2"
group.long 0x6a8++0x3
line.long 0x00 "0x06a8"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP out 3"
group.long 0x6ac++0x3
line.long 0x00 "0x06ac"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP out AXI 1"
group.long 0x6b0++0x3
line.long 0x00 "0x06b0"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP out AXI 2"
group.long 0x6b4++0x3
line.long 0x00 "0x06b4"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP out AXI 3"
group.long 0x6b8++0x3
line.long 0x00 "0x06b8"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "Frame counter ISP PC AXI"
group.long 0x6bc++0x3
line.long 0x00 "0x06bc"
textline "                 "
bitfld.long 0x00 0. " Frame active  , Active video flag  "
bitfld.long 0x00 31. " Frame count overflow  , Counter overflow flag  "
hexmask.long.long 0x00 1.--24. 1. " Frame count  ,Frame count"
TREE.END
TREE "raw_buffers"
group.long 0x800++0x3
line.long 0x00 "0x0800"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 0  , Buffer 0 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 0  ,Pixel data width in bits."
group.long 0x804++0x3
line.long 0x00 "0x0804"
hexmask.long.long 0x00 0.--31. 1. " Base address 0  ,Frame buffer base address."
group.long 0x808++0x3
line.long 0x00 "0x0808"
hexmask.long.long 0x00 0.--31. 1. " Line offset 0  ,Offset in bytes between lines."
group.long 0x80c++0x3
line.long 0x00 "0x080c"
hexmask.long.word 0x00 0.--12. 1. " Active width 0  ,Active width in pixels."
group.long 0x810++0x3
line.long 0x00 "0x0810"
hexmask.long.word 0x00 0.--12. 1. " Active height 0  ,Active height in pixels."
group.long 0x814++0x3
line.long 0x00 "0x0814"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 0  ,Number of lines in curcular buffer."
group.long 0x818++0x3
line.long 0x00 "0x0818"
hexmask.long.byte 0x00 0.--3. 1. " Status 0  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0x81c++0x3
line.long 0x00 "0x081c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 0  ,Buffer data CRC."
group.long 0x820++0x3
line.long 0x00 "0x0820"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 1  , Buffer 1 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 1  ,Pixel data width in bits."
group.long 0x824++0x3
line.long 0x00 "0x0824"
hexmask.long.long 0x00 0.--31. 1. " Base address 1  ,Frame buffer base address."
group.long 0x828++0x3
line.long 0x00 "0x0828"
hexmask.long.long 0x00 0.--31. 1. " Line offset 1  ,Offset in bytes between lines."
group.long 0x82c++0x3
line.long 0x00 "0x082c"
hexmask.long.word 0x00 0.--12. 1. " Active width 1  ,Active width in pixels."
group.long 0x830++0x3
line.long 0x00 "0x0830"
hexmask.long.word 0x00 0.--12. 1. " Active height 1  ,Active height in pixels."
group.long 0x834++0x3
line.long 0x00 "0x0834"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 1  ,Number of lines in curcular buffer."
group.long 0x838++0x3
line.long 0x00 "0x0838"
hexmask.long.byte 0x00 0.--3. 1. " Status 1  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0x83c++0x3
line.long 0x00 "0x083c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 1  ,Buffer data CRC."
group.long 0x840++0x3
line.long 0x00 "0x0840"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 2  , Buffer 2 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 2  ,Pixel data width in bits."
group.long 0x844++0x3
line.long 0x00 "0x0844"
hexmask.long.long 0x00 0.--31. 1. " Base address 2  ,Frame buffer base address."
group.long 0x848++0x3
line.long 0x00 "0x0848"
hexmask.long.long 0x00 0.--31. 1. " Line offset 2  ,Offset in bytes between lines."
group.long 0x84c++0x3
line.long 0x00 "0x084c"
hexmask.long.word 0x00 0.--12. 1. " Active width 2  ,Active width in pixels."
group.long 0x850++0x3
line.long 0x00 "0x0850"
hexmask.long.word 0x00 0.--12. 1. " Active height 2  ,Active height in pixels."
group.long 0x854++0x3
line.long 0x00 "0x0854"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 2  ,Number of lines in curcular buffer."
group.long 0x858++0x3
line.long 0x00 "0x0858"
hexmask.long.byte 0x00 0.--3. 1. " Status 2  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0x85c++0x3
line.long 0x00 "0x085c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 2  ,Buffer data CRC."
group.long 0x860++0x3
line.long 0x00 "0x0860"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 3  , Buffer 3 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 3  ,Pixel data width in bits."
group.long 0x864++0x3
line.long 0x00 "0x0864"
hexmask.long.long 0x00 0.--31. 1. " Base address 3  ,Frame buffer base address."
group.long 0x868++0x3
line.long 0x00 "0x0868"
hexmask.long.long 0x00 0.--31. 1. " Line offset 3  ,Offset in bytes between lines."
group.long 0x86c++0x3
line.long 0x00 "0x086c"
hexmask.long.word 0x00 0.--12. 1. " Active width 3  ,Active width in pixels."
group.long 0x870++0x3
line.long 0x00 "0x0870"
hexmask.long.word 0x00 0.--12. 1. " Active height 3  ,Active height in pixels."
group.long 0x874++0x3
line.long 0x00 "0x0874"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 3  ,Number of lines in curcular buffer."
group.long 0x878++0x3
line.long 0x00 "0x0878"
hexmask.long.byte 0x00 0.--3. 1. " Status 3  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0x87c++0x3
line.long 0x00 "0x087c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 3  ,Buffer data CRC."
group.long 0x880++0x3
line.long 0x00 "0x0880"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 4  , Buffer 4 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 4  ,Pixel data width in bits."
group.long 0x884++0x3
line.long 0x00 "0x0884"
hexmask.long.long 0x00 0.--31. 1. " Base address 4  ,Frame buffer base address."
group.long 0x888++0x3
line.long 0x00 "0x0888"
hexmask.long.long 0x00 0.--31. 1. " Line offset 4  ,Offset in bytes between lines."
group.long 0x88c++0x3
line.long 0x00 "0x088c"
hexmask.long.word 0x00 0.--12. 1. " Active width 4  ,Active width in pixels."
group.long 0x890++0x3
line.long 0x00 "0x0890"
hexmask.long.word 0x00 0.--12. 1. " Active height 4  ,Active height in pixels."
group.long 0x894++0x3
line.long 0x00 "0x0894"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 4  ,Number of lines in curcular buffer."
group.long 0x898++0x3
line.long 0x00 "0x0898"
hexmask.long.byte 0x00 0.--3. 1. " Status 4  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0x89c++0x3
line.long 0x00 "0x089c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 4  ,Buffer data CRC."
group.long 0x8a0++0x3
line.long 0x00 "0x08a0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 5  , Buffer 5 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 5  ,Pixel data width in bits."
group.long 0x8a4++0x3
line.long 0x00 "0x08a4"
hexmask.long.long 0x00 0.--31. 1. " Base address 5  ,Frame buffer base address."
group.long 0x8a8++0x3
line.long 0x00 "0x08a8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 5  ,Offset in bytes between lines."
group.long 0x8ac++0x3
line.long 0x00 "0x08ac"
hexmask.long.word 0x00 0.--12. 1. " Active width 5  ,Active width in pixels."
group.long 0x8b0++0x3
line.long 0x00 "0x08b0"
hexmask.long.word 0x00 0.--12. 1. " Active height 5  ,Active height in pixels."
group.long 0x8b4++0x3
line.long 0x00 "0x08b4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 5  ,Number of lines in curcular buffer."
group.long 0x8b8++0x3
line.long 0x00 "0x08b8"
hexmask.long.byte 0x00 0.--3. 1. " Status 5  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0x8bc++0x3
line.long 0x00 "0x08bc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 5  ,Buffer data CRC."
group.long 0x8c0++0x3
line.long 0x00 "0x08c0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 6  , Buffer 6 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 6  ,Pixel data width in bits."
group.long 0x8c4++0x3
line.long 0x00 "0x08c4"
hexmask.long.long 0x00 0.--31. 1. " Base address 6  ,Frame buffer base address."
group.long 0x8c8++0x3
line.long 0x00 "0x08c8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 6  ,Offset in bytes between lines."
group.long 0x8cc++0x3
line.long 0x00 "0x08cc"
hexmask.long.word 0x00 0.--12. 1. " Active width 6  ,Active width in pixels."
group.long 0x8d0++0x3
line.long 0x00 "0x08d0"
hexmask.long.word 0x00 0.--12. 1. " Active height 6  ,Active height in pixels."
group.long 0x8d4++0x3
line.long 0x00 "0x08d4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 6  ,Number of lines in curcular buffer."
group.long 0x8d8++0x3
line.long 0x00 "0x08d8"
hexmask.long.byte 0x00 0.--3. 1. " Status 6  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0x8dc++0x3
line.long 0x00 "0x08dc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 6  ,Buffer data CRC."
group.long 0x8e0++0x3
line.long 0x00 "0x08e0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 7  , Buffer 7 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 7  ,Pixel data width in bits."
group.long 0x8e4++0x3
line.long 0x00 "0x08e4"
hexmask.long.long 0x00 0.--31. 1. " Base address 7  ,Frame buffer base address."
group.long 0x8e8++0x3
line.long 0x00 "0x08e8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 7  ,Offset in bytes between lines."
group.long 0x8ec++0x3
line.long 0x00 "0x08ec"
hexmask.long.word 0x00 0.--12. 1. " Active width 7  ,Active width in pixels."
group.long 0x8f0++0x3
line.long 0x00 "0x08f0"
hexmask.long.word 0x00 0.--12. 1. " Active height 7  ,Active height in pixels."
group.long 0x8f4++0x3
line.long 0x00 "0x08f4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 7  ,Number of lines in curcular buffer."
group.long 0x8f8++0x3
line.long 0x00 "0x08f8"
hexmask.long.byte 0x00 0.--3. 1. " Status 7  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0x8fc++0x3
line.long 0x00 "0x08fc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 7  ,Buffer data CRC."
group.long 0x900++0x3
line.long 0x00 "0x0900"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 8  , Buffer 8 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 8  ,Pixel data width in bits."
group.long 0x904++0x3
line.long 0x00 "0x0904"
hexmask.long.long 0x00 0.--31. 1. " Base address 8  ,Frame buffer base address."
group.long 0x908++0x3
line.long 0x00 "0x0908"
hexmask.long.long 0x00 0.--31. 1. " Line offset 8  ,Offset in bytes between lines."
group.long 0x90c++0x3
line.long 0x00 "0x090c"
hexmask.long.word 0x00 0.--12. 1. " Active width 8  ,Active width in pixels."
group.long 0x910++0x3
line.long 0x00 "0x0910"
hexmask.long.word 0x00 0.--12. 1. " Active height 8  ,Active height in pixels."
group.long 0x914++0x3
line.long 0x00 "0x0914"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 8  ,Number of lines in curcular buffer."
group.long 0x918++0x3
line.long 0x00 "0x0918"
hexmask.long.byte 0x00 0.--3. 1. " Status 8  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0x91c++0x3
line.long 0x00 "0x091c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 8  ,Buffer data CRC."
group.long 0x920++0x3
line.long 0x00 "0x0920"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 9  , Buffer 9 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 9  ,Pixel data width in bits."
group.long 0x924++0x3
line.long 0x00 "0x0924"
hexmask.long.long 0x00 0.--31. 1. " Base address 9  ,Frame buffer base address."
group.long 0x928++0x3
line.long 0x00 "0x0928"
hexmask.long.long 0x00 0.--31. 1. " Line offset 9  ,Offset in bytes between lines."
group.long 0x92c++0x3
line.long 0x00 "0x092c"
hexmask.long.word 0x00 0.--12. 1. " Active width 9  ,Active width in pixels."
group.long 0x930++0x3
line.long 0x00 "0x0930"
hexmask.long.word 0x00 0.--12. 1. " Active height 9  ,Active height in pixels."
group.long 0x934++0x3
line.long 0x00 "0x0934"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 9  ,Number of lines in curcular buffer."
group.long 0x938++0x3
line.long 0x00 "0x0938"
hexmask.long.byte 0x00 0.--3. 1. " Status 9  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0x93c++0x3
line.long 0x00 "0x093c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 9  ,Buffer data CRC."
TREE.END
TREE "out_buffers"
group.long 0xc00++0x3
line.long 0x00 "0x0c00"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 0  , Buffer 0 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 0  ,Pixel data width in bits."
group.long 0xc04++0x3
line.long 0x00 "0x0c04"
hexmask.long.long 0x00 0.--31. 1. " Base address 0  ,Frame buffer base address."
group.long 0xc08++0x3
line.long 0x00 "0x0c08"
hexmask.long.long 0x00 0.--31. 1. " Line offset 0  ,Offset in bytes between lines."
group.long 0xc0c++0x3
line.long 0x00 "0x0c0c"
hexmask.long.word 0x00 0.--12. 1. " Active width 0  ,Active width in pixels."
group.long 0xc10++0x3
line.long 0x00 "0x0c10"
hexmask.long.word 0x00 0.--12. 1. " Active height 0  ,Active height in pixels."
group.long 0xc14++0x3
line.long 0x00 "0x0c14"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 0  ,Number of lines in curcular buffer."
group.long 0xc18++0x3
line.long 0x00 "0x0c18"
hexmask.long.byte 0x00 0.--3. 1. " Status 0  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xc1c++0x3
line.long 0x00 "0x0c1c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 0  ,Buffer data CRC."
group.long 0xc20++0x3
line.long 0x00 "0x0c20"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 1  , Buffer 1 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 1  ,Pixel data width in bits."
group.long 0xc24++0x3
line.long 0x00 "0x0c24"
hexmask.long.long 0x00 0.--31. 1. " Base address 1  ,Frame buffer base address."
group.long 0xc28++0x3
line.long 0x00 "0x0c28"
hexmask.long.long 0x00 0.--31. 1. " Line offset 1  ,Offset in bytes between lines."
group.long 0xc2c++0x3
line.long 0x00 "0x0c2c"
hexmask.long.word 0x00 0.--12. 1. " Active width 1  ,Active width in pixels."
group.long 0xc30++0x3
line.long 0x00 "0x0c30"
hexmask.long.word 0x00 0.--12. 1. " Active height 1  ,Active height in pixels."
group.long 0xc34++0x3
line.long 0x00 "0x0c34"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 1  ,Number of lines in curcular buffer."
group.long 0xc38++0x3
line.long 0x00 "0x0c38"
hexmask.long.byte 0x00 0.--3. 1. " Status 1  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xc3c++0x3
line.long 0x00 "0x0c3c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 1  ,Buffer data CRC."
group.long 0xc40++0x3
line.long 0x00 "0x0c40"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 2  , Buffer 2 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 2  ,Pixel data width in bits."
group.long 0xc44++0x3
line.long 0x00 "0x0c44"
hexmask.long.long 0x00 0.--31. 1. " Base address 2  ,Frame buffer base address."
group.long 0xc48++0x3
line.long 0x00 "0x0c48"
hexmask.long.long 0x00 0.--31. 1. " Line offset 2  ,Offset in bytes between lines."
group.long 0xc4c++0x3
line.long 0x00 "0x0c4c"
hexmask.long.word 0x00 0.--12. 1. " Active width 2  ,Active width in pixels."
group.long 0xc50++0x3
line.long 0x00 "0x0c50"
hexmask.long.word 0x00 0.--12. 1. " Active height 2  ,Active height in pixels."
group.long 0xc54++0x3
line.long 0x00 "0x0c54"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 2  ,Number of lines in curcular buffer."
group.long 0xc58++0x3
line.long 0x00 "0x0c58"
hexmask.long.byte 0x00 0.--3. 1. " Status 2  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xc5c++0x3
line.long 0x00 "0x0c5c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 2  ,Buffer data CRC."
group.long 0xc60++0x3
line.long 0x00 "0x0c60"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 3  , Buffer 3 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 3  ,Pixel data width in bits."
group.long 0xc64++0x3
line.long 0x00 "0x0c64"
hexmask.long.long 0x00 0.--31. 1. " Base address 3  ,Frame buffer base address."
group.long 0xc68++0x3
line.long 0x00 "0x0c68"
hexmask.long.long 0x00 0.--31. 1. " Line offset 3  ,Offset in bytes between lines."
group.long 0xc6c++0x3
line.long 0x00 "0x0c6c"
hexmask.long.word 0x00 0.--12. 1. " Active width 3  ,Active width in pixels."
group.long 0xc70++0x3
line.long 0x00 "0x0c70"
hexmask.long.word 0x00 0.--12. 1. " Active height 3  ,Active height in pixels."
group.long 0xc74++0x3
line.long 0x00 "0x0c74"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 3  ,Number of lines in curcular buffer."
group.long 0xc78++0x3
line.long 0x00 "0x0c78"
hexmask.long.byte 0x00 0.--3. 1. " Status 3  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xc7c++0x3
line.long 0x00 "0x0c7c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 3  ,Buffer data CRC."
group.long 0xc80++0x3
line.long 0x00 "0x0c80"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 4  , Buffer 4 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 4  ,Pixel data width in bits."
group.long 0xc84++0x3
line.long 0x00 "0x0c84"
hexmask.long.long 0x00 0.--31. 1. " Base address 4  ,Frame buffer base address."
group.long 0xc88++0x3
line.long 0x00 "0x0c88"
hexmask.long.long 0x00 0.--31. 1. " Line offset 4  ,Offset in bytes between lines."
group.long 0xc8c++0x3
line.long 0x00 "0x0c8c"
hexmask.long.word 0x00 0.--12. 1. " Active width 4  ,Active width in pixels."
group.long 0xc90++0x3
line.long 0x00 "0x0c90"
hexmask.long.word 0x00 0.--12. 1. " Active height 4  ,Active height in pixels."
group.long 0xc94++0x3
line.long 0x00 "0x0c94"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 4  ,Number of lines in curcular buffer."
group.long 0xc98++0x3
line.long 0x00 "0x0c98"
hexmask.long.byte 0x00 0.--3. 1. " Status 4  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xc9c++0x3
line.long 0x00 "0x0c9c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 4  ,Buffer data CRC."
group.long 0xca0++0x3
line.long 0x00 "0x0ca0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 5  , Buffer 5 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 5  ,Pixel data width in bits."
group.long 0xca4++0x3
line.long 0x00 "0x0ca4"
hexmask.long.long 0x00 0.--31. 1. " Base address 5  ,Frame buffer base address."
group.long 0xca8++0x3
line.long 0x00 "0x0ca8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 5  ,Offset in bytes between lines."
group.long 0xcac++0x3
line.long 0x00 "0x0cac"
hexmask.long.word 0x00 0.--12. 1. " Active width 5  ,Active width in pixels."
group.long 0xcb0++0x3
line.long 0x00 "0x0cb0"
hexmask.long.word 0x00 0.--12. 1. " Active height 5  ,Active height in pixels."
group.long 0xcb4++0x3
line.long 0x00 "0x0cb4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 5  ,Number of lines in curcular buffer."
group.long 0xcb8++0x3
line.long 0x00 "0x0cb8"
hexmask.long.byte 0x00 0.--3. 1. " Status 5  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xcbc++0x3
line.long 0x00 "0x0cbc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 5  ,Buffer data CRC."
group.long 0xcc0++0x3
line.long 0x00 "0x0cc0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 6  , Buffer 6 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 6  ,Pixel data width in bits."
group.long 0xcc4++0x3
line.long 0x00 "0x0cc4"
hexmask.long.long 0x00 0.--31. 1. " Base address 6  ,Frame buffer base address."
group.long 0xcc8++0x3
line.long 0x00 "0x0cc8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 6  ,Offset in bytes between lines."
group.long 0xccc++0x3
line.long 0x00 "0x0ccc"
hexmask.long.word 0x00 0.--12. 1. " Active width 6  ,Active width in pixels."
group.long 0xcd0++0x3
line.long 0x00 "0x0cd0"
hexmask.long.word 0x00 0.--12. 1. " Active height 6  ,Active height in pixels."
group.long 0xcd4++0x3
line.long 0x00 "0x0cd4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 6  ,Number of lines in curcular buffer."
group.long 0xcd8++0x3
line.long 0x00 "0x0cd8"
hexmask.long.byte 0x00 0.--3. 1. " Status 6  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xcdc++0x3
line.long 0x00 "0x0cdc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 6  ,Buffer data CRC."
group.long 0xce0++0x3
line.long 0x00 "0x0ce0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 7  , Buffer 7 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 7  ,Pixel data width in bits."
group.long 0xce4++0x3
line.long 0x00 "0x0ce4"
hexmask.long.long 0x00 0.--31. 1. " Base address 7  ,Frame buffer base address."
group.long 0xce8++0x3
line.long 0x00 "0x0ce8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 7  ,Offset in bytes between lines."
group.long 0xcec++0x3
line.long 0x00 "0x0cec"
hexmask.long.word 0x00 0.--12. 1. " Active width 7  ,Active width in pixels."
group.long 0xcf0++0x3
line.long 0x00 "0x0cf0"
hexmask.long.word 0x00 0.--12. 1. " Active height 7  ,Active height in pixels."
group.long 0xcf4++0x3
line.long 0x00 "0x0cf4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 7  ,Number of lines in curcular buffer."
group.long 0xcf8++0x3
line.long 0x00 "0x0cf8"
hexmask.long.byte 0x00 0.--3. 1. " Status 7  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xcfc++0x3
line.long 0x00 "0x0cfc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 7  ,Buffer data CRC."
group.long 0xd00++0x3
line.long 0x00 "0x0d00"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 8  , Buffer 8 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 8  ,Pixel data width in bits."
group.long 0xd04++0x3
line.long 0x00 "0x0d04"
hexmask.long.long 0x00 0.--31. 1. " Base address 8  ,Frame buffer base address."
group.long 0xd08++0x3
line.long 0x00 "0x0d08"
hexmask.long.long 0x00 0.--31. 1. " Line offset 8  ,Offset in bytes between lines."
group.long 0xd0c++0x3
line.long 0x00 "0x0d0c"
hexmask.long.word 0x00 0.--12. 1. " Active width 8  ,Active width in pixels."
group.long 0xd10++0x3
line.long 0x00 "0x0d10"
hexmask.long.word 0x00 0.--12. 1. " Active height 8  ,Active height in pixels."
group.long 0xd14++0x3
line.long 0x00 "0x0d14"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 8  ,Number of lines in curcular buffer."
group.long 0xd18++0x3
line.long 0x00 "0x0d18"
hexmask.long.byte 0x00 0.--3. 1. " Status 8  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xd1c++0x3
line.long 0x00 "0x0d1c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 8  ,Buffer data CRC."
group.long 0xd20++0x3
line.long 0x00 "0x0d20"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 9  , Buffer 9 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 9  ,Pixel data width in bits."
group.long 0xd24++0x3
line.long 0x00 "0x0d24"
hexmask.long.long 0x00 0.--31. 1. " Base address 9  ,Frame buffer base address."
group.long 0xd28++0x3
line.long 0x00 "0x0d28"
hexmask.long.long 0x00 0.--31. 1. " Line offset 9  ,Offset in bytes between lines."
group.long 0xd2c++0x3
line.long 0x00 "0x0d2c"
hexmask.long.word 0x00 0.--12. 1. " Active width 9  ,Active width in pixels."
group.long 0xd30++0x3
line.long 0x00 "0x0d30"
hexmask.long.word 0x00 0.--12. 1. " Active height 9  ,Active height in pixels."
group.long 0xd34++0x3
line.long 0x00 "0x0d34"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 9  ,Number of lines in curcular buffer."
group.long 0xd38++0x3
line.long 0x00 "0x0d38"
hexmask.long.byte 0x00 0.--3. 1. " Status 9  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xd3c++0x3
line.long 0x00 "0x0d3c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 9  ,Buffer data CRC."
group.long 0xd40++0x3
line.long 0x00 "0x0d40"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 10  , Buffer 10 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 10  ,Pixel data width in bits."
group.long 0xd44++0x3
line.long 0x00 "0x0d44"
hexmask.long.long 0x00 0.--31. 1. " Base address 10  ,Frame buffer base address."
group.long 0xd48++0x3
line.long 0x00 "0x0d48"
hexmask.long.long 0x00 0.--31. 1. " Line offset 10  ,Offset in bytes between lines."
group.long 0xd4c++0x3
line.long 0x00 "0x0d4c"
hexmask.long.word 0x00 0.--12. 1. " Active width 10  ,Active width in pixels."
group.long 0xd50++0x3
line.long 0x00 "0x0d50"
hexmask.long.word 0x00 0.--12. 1. " Active height 10  ,Active height in pixels."
group.long 0xd54++0x3
line.long 0x00 "0x0d54"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 10  ,Number of lines in curcular buffer."
group.long 0xd58++0x3
line.long 0x00 "0x0d58"
hexmask.long.byte 0x00 0.--3. 1. " Status 10  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xd5c++0x3
line.long 0x00 "0x0d5c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 10  ,Buffer data CRC."
group.long 0xd60++0x3
line.long 0x00 "0x0d60"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 11  , Buffer 11 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 11  ,Pixel data width in bits."
group.long 0xd64++0x3
line.long 0x00 "0x0d64"
hexmask.long.long 0x00 0.--31. 1. " Base address 11  ,Frame buffer base address."
group.long 0xd68++0x3
line.long 0x00 "0x0d68"
hexmask.long.long 0x00 0.--31. 1. " Line offset 11  ,Offset in bytes between lines."
group.long 0xd6c++0x3
line.long 0x00 "0x0d6c"
hexmask.long.word 0x00 0.--12. 1. " Active width 11  ,Active width in pixels."
group.long 0xd70++0x3
line.long 0x00 "0x0d70"
hexmask.long.word 0x00 0.--12. 1. " Active height 11  ,Active height in pixels."
group.long 0xd74++0x3
line.long 0x00 "0x0d74"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 11  ,Number of lines in curcular buffer."
group.long 0xd78++0x3
line.long 0x00 "0x0d78"
hexmask.long.byte 0x00 0.--3. 1. " Status 11  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xd7c++0x3
line.long 0x00 "0x0d7c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 11  ,Buffer data CRC."
group.long 0xd80++0x3
line.long 0x00 "0x0d80"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 12  , Buffer 12 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 12  ,Pixel data width in bits."
group.long 0xd84++0x3
line.long 0x00 "0x0d84"
hexmask.long.long 0x00 0.--31. 1. " Base address 12  ,Frame buffer base address."
group.long 0xd88++0x3
line.long 0x00 "0x0d88"
hexmask.long.long 0x00 0.--31. 1. " Line offset 12  ,Offset in bytes between lines."
group.long 0xd8c++0x3
line.long 0x00 "0x0d8c"
hexmask.long.word 0x00 0.--12. 1. " Active width 12  ,Active width in pixels."
group.long 0xd90++0x3
line.long 0x00 "0x0d90"
hexmask.long.word 0x00 0.--12. 1. " Active height 12  ,Active height in pixels."
group.long 0xd94++0x3
line.long 0x00 "0x0d94"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 12  ,Number of lines in curcular buffer."
group.long 0xd98++0x3
line.long 0x00 "0x0d98"
hexmask.long.byte 0x00 0.--3. 1. " Status 12  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xd9c++0x3
line.long 0x00 "0x0d9c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 12  ,Buffer data CRC."
group.long 0xda0++0x3
line.long 0x00 "0x0da0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 13  , Buffer 13 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 13  ,Pixel data width in bits."
group.long 0xda4++0x3
line.long 0x00 "0x0da4"
hexmask.long.long 0x00 0.--31. 1. " Base address 13  ,Frame buffer base address."
group.long 0xda8++0x3
line.long 0x00 "0x0da8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 13  ,Offset in bytes between lines."
group.long 0xdac++0x3
line.long 0x00 "0x0dac"
hexmask.long.word 0x00 0.--12. 1. " Active width 13  ,Active width in pixels."
group.long 0xdb0++0x3
line.long 0x00 "0x0db0"
hexmask.long.word 0x00 0.--12. 1. " Active height 13  ,Active height in pixels."
group.long 0xdb4++0x3
line.long 0x00 "0x0db4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 13  ,Number of lines in curcular buffer."
group.long 0xdb8++0x3
line.long 0x00 "0x0db8"
hexmask.long.byte 0x00 0.--3. 1. " Status 13  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xdbc++0x3
line.long 0x00 "0x0dbc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 13  ,Buffer data CRC."
group.long 0xdc0++0x3
line.long 0x00 "0x0dc0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 14  , Buffer 14 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 14  ,Pixel data width in bits."
group.long 0xdc4++0x3
line.long 0x00 "0x0dc4"
hexmask.long.long 0x00 0.--31. 1. " Base address 14  ,Frame buffer base address."
group.long 0xdc8++0x3
line.long 0x00 "0x0dc8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 14  ,Offset in bytes between lines."
group.long 0xdcc++0x3
line.long 0x00 "0x0dcc"
hexmask.long.word 0x00 0.--12. 1. " Active width 14  ,Active width in pixels."
group.long 0xdd0++0x3
line.long 0x00 "0x0dd0"
hexmask.long.word 0x00 0.--12. 1. " Active height 14  ,Active height in pixels."
group.long 0xdd4++0x3
line.long 0x00 "0x0dd4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 14  ,Number of lines in curcular buffer."
group.long 0xdd8++0x3
line.long 0x00 "0x0dd8"
hexmask.long.byte 0x00 0.--3. 1. " Status 14  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xddc++0x3
line.long 0x00 "0x0ddc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 14  ,Buffer data CRC."
group.long 0xde0++0x3
line.long 0x00 "0x0de0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 15  , Buffer 15 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 15  ,Pixel data width in bits."
group.long 0xde4++0x3
line.long 0x00 "0x0de4"
hexmask.long.long 0x00 0.--31. 1. " Base address 15  ,Frame buffer base address."
group.long 0xde8++0x3
line.long 0x00 "0x0de8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 15  ,Offset in bytes between lines."
group.long 0xdec++0x3
line.long 0x00 "0x0dec"
hexmask.long.word 0x00 0.--12. 1. " Active width 15  ,Active width in pixels."
group.long 0xdf0++0x3
line.long 0x00 "0x0df0"
hexmask.long.word 0x00 0.--12. 1. " Active height 15  ,Active height in pixels."
group.long 0xdf4++0x3
line.long 0x00 "0x0df4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 15  ,Number of lines in curcular buffer."
group.long 0xdf8++0x3
line.long 0x00 "0x0df8"
hexmask.long.byte 0x00 0.--3. 1. " Status 15  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xdfc++0x3
line.long 0x00 "0x0dfc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 15  ,Buffer data CRC."
group.long 0xe00++0x3
line.long 0x00 "0x0e00"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 16  , Buffer 16 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 16  ,Pixel data width in bits."
group.long 0xe04++0x3
line.long 0x00 "0x0e04"
hexmask.long.long 0x00 0.--31. 1. " Base address 16  ,Frame buffer base address."
group.long 0xe08++0x3
line.long 0x00 "0x0e08"
hexmask.long.long 0x00 0.--31. 1. " Line offset 16  ,Offset in bytes between lines."
group.long 0xe0c++0x3
line.long 0x00 "0x0e0c"
hexmask.long.word 0x00 0.--12. 1. " Active width 16  ,Active width in pixels."
group.long 0xe10++0x3
line.long 0x00 "0x0e10"
hexmask.long.word 0x00 0.--12. 1. " Active height 16  ,Active height in pixels."
group.long 0xe14++0x3
line.long 0x00 "0x0e14"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 16  ,Number of lines in curcular buffer."
group.long 0xe18++0x3
line.long 0x00 "0x0e18"
hexmask.long.byte 0x00 0.--3. 1. " Status 16  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xe1c++0x3
line.long 0x00 "0x0e1c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 16  ,Buffer data CRC."
group.long 0xe20++0x3
line.long 0x00 "0x0e20"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 17  , Buffer 17 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 17  ,Pixel data width in bits."
group.long 0xe24++0x3
line.long 0x00 "0x0e24"
hexmask.long.long 0x00 0.--31. 1. " Base address 17  ,Frame buffer base address."
group.long 0xe28++0x3
line.long 0x00 "0x0e28"
hexmask.long.long 0x00 0.--31. 1. " Line offset 17  ,Offset in bytes between lines."
group.long 0xe2c++0x3
line.long 0x00 "0x0e2c"
hexmask.long.word 0x00 0.--12. 1. " Active width 17  ,Active width in pixels."
group.long 0xe30++0x3
line.long 0x00 "0x0e30"
hexmask.long.word 0x00 0.--12. 1. " Active height 17  ,Active height in pixels."
group.long 0xe34++0x3
line.long 0x00 "0x0e34"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 17  ,Number of lines in curcular buffer."
group.long 0xe38++0x3
line.long 0x00 "0x0e38"
hexmask.long.byte 0x00 0.--3. 1. " Status 17  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xe3c++0x3
line.long 0x00 "0x0e3c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 17  ,Buffer data CRC."
group.long 0xe40++0x3
line.long 0x00 "0x0e40"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 18  , Buffer 18 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 18  ,Pixel data width in bits."
group.long 0xe44++0x3
line.long 0x00 "0x0e44"
hexmask.long.long 0x00 0.--31. 1. " Base address 18  ,Frame buffer base address."
group.long 0xe48++0x3
line.long 0x00 "0x0e48"
hexmask.long.long 0x00 0.--31. 1. " Line offset 18  ,Offset in bytes between lines."
group.long 0xe4c++0x3
line.long 0x00 "0x0e4c"
hexmask.long.word 0x00 0.--12. 1. " Active width 18  ,Active width in pixels."
group.long 0xe50++0x3
line.long 0x00 "0x0e50"
hexmask.long.word 0x00 0.--12. 1. " Active height 18  ,Active height in pixels."
group.long 0xe54++0x3
line.long 0x00 "0x0e54"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 18  ,Number of lines in curcular buffer."
group.long 0xe58++0x3
line.long 0x00 "0x0e58"
hexmask.long.byte 0x00 0.--3. 1. " Status 18  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xe5c++0x3
line.long 0x00 "0x0e5c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 18  ,Buffer data CRC."
group.long 0xe60++0x3
line.long 0x00 "0x0e60"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 19  , Buffer 19 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 19  ,Pixel data width in bits."
group.long 0xe64++0x3
line.long 0x00 "0x0e64"
hexmask.long.long 0x00 0.--31. 1. " Base address 19  ,Frame buffer base address."
group.long 0xe68++0x3
line.long 0x00 "0x0e68"
hexmask.long.long 0x00 0.--31. 1. " Line offset 19  ,Offset in bytes between lines."
group.long 0xe6c++0x3
line.long 0x00 "0x0e6c"
hexmask.long.word 0x00 0.--12. 1. " Active width 19  ,Active width in pixels."
group.long 0xe70++0x3
line.long 0x00 "0x0e70"
hexmask.long.word 0x00 0.--12. 1. " Active height 19  ,Active height in pixels."
group.long 0xe74++0x3
line.long 0x00 "0x0e74"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 19  ,Number of lines in curcular buffer."
group.long 0xe78++0x3
line.long 0x00 "0x0e78"
hexmask.long.byte 0x00 0.--3. 1. " Status 19  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xe7c++0x3
line.long 0x00 "0x0e7c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 19  ,Buffer data CRC."
group.long 0xe80++0x3
line.long 0x00 "0x0e80"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 20  , Buffer 20 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 20  ,Pixel data width in bits."
group.long 0xe84++0x3
line.long 0x00 "0x0e84"
hexmask.long.long 0x00 0.--31. 1. " Base address 20  ,Frame buffer base address."
group.long 0xe88++0x3
line.long 0x00 "0x0e88"
hexmask.long.long 0x00 0.--31. 1. " Line offset 20  ,Offset in bytes between lines."
group.long 0xe8c++0x3
line.long 0x00 "0x0e8c"
hexmask.long.word 0x00 0.--12. 1. " Active width 20  ,Active width in pixels."
group.long 0xe90++0x3
line.long 0x00 "0x0e90"
hexmask.long.word 0x00 0.--12. 1. " Active height 20  ,Active height in pixels."
group.long 0xe94++0x3
line.long 0x00 "0x0e94"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 20  ,Number of lines in curcular buffer."
group.long 0xe98++0x3
line.long 0x00 "0x0e98"
hexmask.long.byte 0x00 0.--3. 1. " Status 20  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xe9c++0x3
line.long 0x00 "0x0e9c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 20  ,Buffer data CRC."
group.long 0xea0++0x3
line.long 0x00 "0x0ea0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 21  , Buffer 21 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 21  ,Pixel data width in bits."
group.long 0xea4++0x3
line.long 0x00 "0x0ea4"
hexmask.long.long 0x00 0.--31. 1. " Base address 21  ,Frame buffer base address."
group.long 0xea8++0x3
line.long 0x00 "0x0ea8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 21  ,Offset in bytes between lines."
group.long 0xeac++0x3
line.long 0x00 "0x0eac"
hexmask.long.word 0x00 0.--12. 1. " Active width 21  ,Active width in pixels."
group.long 0xeb0++0x3
line.long 0x00 "0x0eb0"
hexmask.long.word 0x00 0.--12. 1. " Active height 21  ,Active height in pixels."
group.long 0xeb4++0x3
line.long 0x00 "0x0eb4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 21  ,Number of lines in curcular buffer."
group.long 0xeb8++0x3
line.long 0x00 "0x0eb8"
hexmask.long.byte 0x00 0.--3. 1. " Status 21  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xebc++0x3
line.long 0x00 "0x0ebc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 21  ,Buffer data CRC."
group.long 0xec0++0x3
line.long 0x00 "0x0ec0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 22  , Buffer 22 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 22  ,Pixel data width in bits."
group.long 0xec4++0x3
line.long 0x00 "0x0ec4"
hexmask.long.long 0x00 0.--31. 1. " Base address 22  ,Frame buffer base address."
group.long 0xec8++0x3
line.long 0x00 "0x0ec8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 22  ,Offset in bytes between lines."
group.long 0xecc++0x3
line.long 0x00 "0x0ecc"
hexmask.long.word 0x00 0.--12. 1. " Active width 22  ,Active width in pixels."
group.long 0xed0++0x3
line.long 0x00 "0x0ed0"
hexmask.long.word 0x00 0.--12. 1. " Active height 22  ,Active height in pixels."
group.long 0xed4++0x3
line.long 0x00 "0x0ed4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 22  ,Number of lines in curcular buffer."
group.long 0xed8++0x3
line.long 0x00 "0x0ed8"
hexmask.long.byte 0x00 0.--3. 1. " Status 22  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xedc++0x3
line.long 0x00 "0x0edc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 22  ,Buffer data CRC."
group.long 0xee0++0x3
line.long 0x00 "0x0ee0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 23  , Buffer 23 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 23  ,Pixel data width in bits."
group.long 0xee4++0x3
line.long 0x00 "0x0ee4"
hexmask.long.long 0x00 0.--31. 1. " Base address 23  ,Frame buffer base address."
group.long 0xee8++0x3
line.long 0x00 "0x0ee8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 23  ,Offset in bytes between lines."
group.long 0xeec++0x3
line.long 0x00 "0x0eec"
hexmask.long.word 0x00 0.--12. 1. " Active width 23  ,Active width in pixels."
group.long 0xef0++0x3
line.long 0x00 "0x0ef0"
hexmask.long.word 0x00 0.--12. 1. " Active height 23  ,Active height in pixels."
group.long 0xef4++0x3
line.long 0x00 "0x0ef4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 23  ,Number of lines in curcular buffer."
group.long 0xef8++0x3
line.long 0x00 "0x0ef8"
hexmask.long.byte 0x00 0.--3. 1. " Status 23  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xefc++0x3
line.long 0x00 "0x0efc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 23  ,Buffer data CRC."
group.long 0xf00++0x3
line.long 0x00 "0x0f00"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 24  , Buffer 24 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 24  ,Pixel data width in bits."
group.long 0xf04++0x3
line.long 0x00 "0x0f04"
hexmask.long.long 0x00 0.--31. 1. " Base address 24  ,Frame buffer base address."
group.long 0xf08++0x3
line.long 0x00 "0x0f08"
hexmask.long.long 0x00 0.--31. 1. " Line offset 24  ,Offset in bytes between lines."
group.long 0xf0c++0x3
line.long 0x00 "0x0f0c"
hexmask.long.word 0x00 0.--12. 1. " Active width 24  ,Active width in pixels."
group.long 0xf10++0x3
line.long 0x00 "0x0f10"
hexmask.long.word 0x00 0.--12. 1. " Active height 24  ,Active height in pixels."
group.long 0xf14++0x3
line.long 0x00 "0x0f14"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 24  ,Number of lines in curcular buffer."
group.long 0xf18++0x3
line.long 0x00 "0x0f18"
hexmask.long.byte 0x00 0.--3. 1. " Status 24  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xf1c++0x3
line.long 0x00 "0x0f1c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 24  ,Buffer data CRC."
group.long 0xf20++0x3
line.long 0x00 "0x0f20"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 25  , Buffer 25 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 25  ,Pixel data width in bits."
group.long 0xf24++0x3
line.long 0x00 "0x0f24"
hexmask.long.long 0x00 0.--31. 1. " Base address 25  ,Frame buffer base address."
group.long 0xf28++0x3
line.long 0x00 "0x0f28"
hexmask.long.long 0x00 0.--31. 1. " Line offset 25  ,Offset in bytes between lines."
group.long 0xf2c++0x3
line.long 0x00 "0x0f2c"
hexmask.long.word 0x00 0.--12. 1. " Active width 25  ,Active width in pixels."
group.long 0xf30++0x3
line.long 0x00 "0x0f30"
hexmask.long.word 0x00 0.--12. 1. " Active height 25  ,Active height in pixels."
group.long 0xf34++0x3
line.long 0x00 "0x0f34"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 25  ,Number of lines in curcular buffer."
group.long 0xf38++0x3
line.long 0x00 "0x0f38"
hexmask.long.byte 0x00 0.--3. 1. " Status 25  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xf3c++0x3
line.long 0x00 "0x0f3c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 25  ,Buffer data CRC."
group.long 0xf40++0x3
line.long 0x00 "0x0f40"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 26  , Buffer 26 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 26  ,Pixel data width in bits."
group.long 0xf44++0x3
line.long 0x00 "0x0f44"
hexmask.long.long 0x00 0.--31. 1. " Base address 26  ,Frame buffer base address."
group.long 0xf48++0x3
line.long 0x00 "0x0f48"
hexmask.long.long 0x00 0.--31. 1. " Line offset 26  ,Offset in bytes between lines."
group.long 0xf4c++0x3
line.long 0x00 "0x0f4c"
hexmask.long.word 0x00 0.--12. 1. " Active width 26  ,Active width in pixels."
group.long 0xf50++0x3
line.long 0x00 "0x0f50"
hexmask.long.word 0x00 0.--12. 1. " Active height 26  ,Active height in pixels."
group.long 0xf54++0x3
line.long 0x00 "0x0f54"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 26  ,Number of lines in curcular buffer."
group.long 0xf58++0x3
line.long 0x00 "0x0f58"
hexmask.long.byte 0x00 0.--3. 1. " Status 26  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xf5c++0x3
line.long 0x00 "0x0f5c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 26  ,Buffer data CRC."
group.long 0xf60++0x3
line.long 0x00 "0x0f60"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 27  , Buffer 27 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 27  ,Pixel data width in bits."
group.long 0xf64++0x3
line.long 0x00 "0x0f64"
hexmask.long.long 0x00 0.--31. 1. " Base address 27  ,Frame buffer base address."
group.long 0xf68++0x3
line.long 0x00 "0x0f68"
hexmask.long.long 0x00 0.--31. 1. " Line offset 27  ,Offset in bytes between lines."
group.long 0xf6c++0x3
line.long 0x00 "0x0f6c"
hexmask.long.word 0x00 0.--12. 1. " Active width 27  ,Active width in pixels."
group.long 0xf70++0x3
line.long 0x00 "0x0f70"
hexmask.long.word 0x00 0.--12. 1. " Active height 27  ,Active height in pixels."
group.long 0xf74++0x3
line.long 0x00 "0x0f74"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 27  ,Number of lines in curcular buffer."
group.long 0xf78++0x3
line.long 0x00 "0x0f78"
hexmask.long.byte 0x00 0.--3. 1. " Status 27  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xf7c++0x3
line.long 0x00 "0x0f7c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 27  ,Buffer data CRC."
group.long 0xf80++0x3
line.long 0x00 "0x0f80"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 28  , Buffer 28 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 28  ,Pixel data width in bits."
group.long 0xf84++0x3
line.long 0x00 "0x0f84"
hexmask.long.long 0x00 0.--31. 1. " Base address 28  ,Frame buffer base address."
group.long 0xf88++0x3
line.long 0x00 "0x0f88"
hexmask.long.long 0x00 0.--31. 1. " Line offset 28  ,Offset in bytes between lines."
group.long 0xf8c++0x3
line.long 0x00 "0x0f8c"
hexmask.long.word 0x00 0.--12. 1. " Active width 28  ,Active width in pixels."
group.long 0xf90++0x3
line.long 0x00 "0x0f90"
hexmask.long.word 0x00 0.--12. 1. " Active height 28  ,Active height in pixels."
group.long 0xf94++0x3
line.long 0x00 "0x0f94"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 28  ,Number of lines in curcular buffer."
group.long 0xf98++0x3
line.long 0x00 "0x0f98"
hexmask.long.byte 0x00 0.--3. 1. " Status 28  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xf9c++0x3
line.long 0x00 "0x0f9c"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 28  ,Buffer data CRC."
group.long 0xfa0++0x3
line.long 0x00 "0x0fa0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 29  , Buffer 29 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 29  ,Pixel data width in bits."
group.long 0xfa4++0x3
line.long 0x00 "0x0fa4"
hexmask.long.long 0x00 0.--31. 1. " Base address 29  ,Frame buffer base address."
group.long 0xfa8++0x3
line.long 0x00 "0x0fa8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 29  ,Offset in bytes between lines."
group.long 0xfac++0x3
line.long 0x00 "0x0fac"
hexmask.long.word 0x00 0.--12. 1. " Active width 29  ,Active width in pixels."
group.long 0xfb0++0x3
line.long 0x00 "0x0fb0"
hexmask.long.word 0x00 0.--12. 1. " Active height 29  ,Active height in pixels."
group.long 0xfb4++0x3
line.long 0x00 "0x0fb4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 29  ,Number of lines in curcular buffer."
group.long 0xfb8++0x3
line.long 0x00 "0x0fb8"
hexmask.long.byte 0x00 0.--3. 1. " Status 29  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xfbc++0x3
line.long 0x00 "0x0fbc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 29  ,Buffer data CRC."
group.long 0xfc0++0x3
line.long 0x00 "0x0fc0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 30  , Buffer 30 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 30  ,Pixel data width in bits."
group.long 0xfc4++0x3
line.long 0x00 "0x0fc4"
hexmask.long.long 0x00 0.--31. 1. " Base address 30  ,Frame buffer base address."
group.long 0xfc8++0x3
line.long 0x00 "0x0fc8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 30  ,Offset in bytes between lines."
group.long 0xfcc++0x3
line.long 0x00 "0x0fcc"
hexmask.long.word 0x00 0.--12. 1. " Active width 30  ,Active width in pixels."
group.long 0xfd0++0x3
line.long 0x00 "0x0fd0"
hexmask.long.word 0x00 0.--12. 1. " Active height 30  ,Active height in pixels."
group.long 0xfd4++0x3
line.long 0x00 "0x0fd4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 30  ,Number of lines in curcular buffer."
group.long 0xfd8++0x3
line.long 0x00 "0x0fd8"
hexmask.long.byte 0x00 0.--3. 1. " Status 30  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xfdc++0x3
line.long 0x00 "0x0fdc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 30  ,Buffer data CRC."
group.long 0xfe0++0x3
line.long 0x00 "0x0fe0"
textline "                 "
bitfld.long 0x00 0. " Buffer valid 31  , Buffer 31 configuration valid flag.  "
hexmask.long.byte 0x00 8.--15. 1. " Data width 31  ,Pixel data width in bits."
group.long 0xfe4++0x3
line.long 0x00 "0x0fe4"
hexmask.long.long 0x00 0.--31. 1. " Base address 31  ,Frame buffer base address."
group.long 0xfe8++0x3
line.long 0x00 "0x0fe8"
hexmask.long.long 0x00 0.--31. 1. " Line offset 31  ,Offset in bytes between lines."
group.long 0xfec++0x3
line.long 0x00 "0x0fec"
hexmask.long.word 0x00 0.--12. 1. " Active width 31  ,Active width in pixels."
group.long 0xff0++0x3
line.long 0x00 "0x0ff0"
hexmask.long.word 0x00 0.--12. 1. " Active height 31  ,Active height in pixels."
group.long 0xff4++0x3
line.long 0x00 "0x0ff4"
hexmask.long.word 0x00 0.--12. 1. " Height modulo 31  ,Number of lines in curcular buffer."
group.long 0xff8++0x3
line.long 0x00 "0x0ff8"
hexmask.long.byte 0x00 0.--3. 1. " Status 31  ,Buffer status: 0 - empty; 1 - filled; 2 - writing; 3 - write canceling; 4 - reading; 5 - read canceling; 6 - reading+writing; 7 - cancelled"
rgroup.long 0xffc++0x3
line.long 0x00 "0x0ffc"
hexmask.long.long 0x00 0.--31. 1. " Buffer CRC 31  ,Buffer data CRC."
TREE.END
TREE "faults_cfg"
group.long 0x1000++0x3
line.long 0x00 "0x1000"
textline "                 "
bitfld.long 0x00 0. " Mask config pclk2 top fault s address range  , Config pclk2 top: Mask of config pclk2 top fault s address range.  "
bitfld.long 0x00 1. " Mask config pclk2 top fault h rvalid  , Config pclk2 top: Mask of config pclk2 top fault h rvalid.  "
bitfld.long 0x00 2. " Mask config pclk top fault s address range  , Config pclk top: Mask of config pclk top fault s address range.  "
bitfld.long 0x00 3. " Mask config pclk top fault h rvalid  , Config pclk top: Mask of config pclk top fault h rvalid.  "
textline "                 "
bitfld.long 0x00 4. " Mask config top apb fault s address range  , Config top apb: Mask of config top apb fault s address range.  "
bitfld.long 0x00 5. " Mask config top apb fault h rvalid  , Config top apb: Mask of config top apb fault h rvalid.  "
bitfld.long 0x00 6. " Mask error active width below limit  , Frame check sensor 1: Mask of error active width below limit.  "
bitfld.long 0x00 7. " Mask error active width above limit  , Frame check sensor 1: Mask of error active width above limit.  "
textline "                 "
bitfld.long 0x00 8. " Mask error active height below limit  , Frame check sensor 1: Mask of error active height below limit.  "
bitfld.long 0x00 9. " Mask error active height above limit  , Frame check sensor 1: Mask of error active height above limit.  "
bitfld.long 0x00 10. " Mask error horizontal blank below limit  , Frame check sensor 1: Mask of error horizontal blank below limit.  "
bitfld.long 0x00 11. " Mask error horizontal blank above limit  , Frame check sensor 1: Mask of error horizontal blank above limit.  "
textline "                 "
bitfld.long 0x00 12. " Mask error vertical blank below limit  , Frame check sensor 1: Mask of error vertical blank below limit.  "
bitfld.long 0x00 13. " Mask error vertical blank above limit  , Frame check sensor 1: Mask of error vertical blank above limit.  "
bitfld.long 0x00 14. " Mask error field during active video  , Frame check sensor 1: Mask of error field during active video.  "
bitfld.long 0x00 15. " Mask error extra field during vblanking  , Frame check sensor 1: Mask of error extra field during vblanking.  "
textline "                 "
bitfld.long 0x00 16. " Mask error manual trigger  , Frame check sensor 1: Mask of error manual trigger.  "
bitfld.long 0x00 17. " Mask error internal fault  , Frame check sensor 1: Mask of error internal fault.  "
bitfld.long 0x00 18. " Mask config vclk top fault s address range  , Config vclk top: Mask of config vclk top fault s address range.  "
bitfld.long 0x00 19. " Mask config vclk top fault h rvalid  , Config vclk top: Mask of config vclk top fault h rvalid.  "
textline "                 "
bitfld.long 0x00 20. " Mask config frontend top fault s address range  , Config frontend top: Mask of config frontend top fault s address range.  "
bitfld.long 0x00 21. " Mask config frontend top fault h rvalid  , Config frontend top: Mask of config frontend top fault h rvalid.  "
bitfld.long 0x00 22. " Mask config top cdma fault s address range  , Config top cdma: Mask of config top cdma fault s address range.  "
bitfld.long 0x00 23. " Mask config top cdma fault h rvalid  , Config top cdma: Mask of config top cdma fault h rvalid.  "
textline "                 "
bitfld.long 0x00 24. " Mask mcfe error serializer1 unsupported format  , Mcfe: Mask of mcfe error serializer1 unsupported format.  "
bitfld.long 0x00 25. " Mask mcfe error serializer1 output overflow  , Mcfe: Mask of mcfe error serializer1 output overflow.  "
bitfld.long 0x00 26. " Mask mcfe error fifo in crc1 fifo crc mismatch  , Mcfe: Mask of mcfe error fifo in crc1 fifo crc mismatch.  "
bitfld.long 0x00 27. " Mask mcfe error fifo in crc1 crc fifo overflow  , Mcfe: Mask of mcfe error fifo in crc1 crc fifo overflow.  "
textline "                 "
bitfld.long 0x00 28. " Mask mcfe error axi writer1 bresp  , Mcfe: Mask of mcfe error axi writer1 bresp.  "
bitfld.long 0x00 29. " Mask mcfe error axi writer1 awmaxwait  , Mcfe: Mask of mcfe error axi writer1 awmaxwait.  "
bitfld.long 0x00 30. " Mask mcfe error axi writer1 wmaxwait  , Mcfe: Mask of mcfe error axi writer1 wmaxwait.  "
bitfld.long 0x00 31. " Mask mcfe error axi writer1 wxact ostand  , Mcfe: Mask of mcfe error axi writer1 wxact ostand.  "
group.long 0x1004++0x3
line.long 0x00 "0x1004"
textline "                 "
bitfld.long 0x00 0. " Mask mcfe error axi writer1 user intfc  , Mcfe: Mask of mcfe error axi writer1 user intfc.  "
bitfld.long 0x00 1. " Mask mcfe error axi writer1 fifo fail full  , Mcfe: Mask of mcfe error axi writer1 fifo fail full.  "
bitfld.long 0x00 2. " Mask mcfe error axi writer1 fifo fail empty  , Mcfe: Mask of mcfe error axi writer1 fifo fail empty.  "
bitfld.long 0x00 3. " Mask mcfe error axi writer1 frame dropped  , Mcfe: Mask of mcfe error axi writer1 frame dropped.  "
textline "                 "
bitfld.long 0x00 4. " Mask mcfe error fb manager1 internal  , Mcfe: Mask of mcfe error fb manager1 internal.  "
bitfld.long 0x00 5. " Mask mcfe error serializer2 unsupported format  , Mcfe: Mask of mcfe error serializer2 unsupported format.  "
bitfld.long 0x00 6. " Mask mcfe error serializer2 output overflow  , Mcfe: Mask of mcfe error serializer2 output overflow.  "
bitfld.long 0x00 7. " Mask mcfe error fifo in crc2 fifo crc mismatch  , Mcfe: Mask of mcfe error fifo in crc2 fifo crc mismatch.  "
textline "                 "
bitfld.long 0x00 8. " Mask mcfe error fifo in crc2 crc fifo overflow  , Mcfe: Mask of mcfe error fifo in crc2 crc fifo overflow.  "
bitfld.long 0x00 9. " Mask mcfe error axi writer2 bresp  , Mcfe: Mask of mcfe error axi writer2 bresp.  "
bitfld.long 0x00 10. " Mask mcfe error axi writer2 awmaxwait  , Mcfe: Mask of mcfe error axi writer2 awmaxwait.  "
bitfld.long 0x00 11. " Mask mcfe error axi writer2 wmaxwait  , Mcfe: Mask of mcfe error axi writer2 wmaxwait.  "
textline "                 "
bitfld.long 0x00 12. " Mask mcfe error axi writer2 wxact ostand  , Mcfe: Mask of mcfe error axi writer2 wxact ostand.  "
bitfld.long 0x00 13. " Mask mcfe error axi writer2 user intfc  , Mcfe: Mask of mcfe error axi writer2 user intfc.  "
bitfld.long 0x00 14. " Mask mcfe error axi writer2 fifo fail full  , Mcfe: Mask of mcfe error axi writer2 fifo fail full.  "
bitfld.long 0x00 15. " Mask mcfe error axi writer2 fifo fail empty  , Mcfe: Mask of mcfe error axi writer2 fifo fail empty.  "
textline "                 "
bitfld.long 0x00 16. " Mask mcfe error axi writer2 frame dropped  , Mcfe: Mask of mcfe error axi writer2 frame dropped.  "
bitfld.long 0x00 17. " Mask mcfe error fb manager2 internal  , Mcfe: Mask of mcfe error fb manager2 internal.  "
bitfld.long 0x00 18. " Mask mcfe error serializer3 unsupported format  , Mcfe: Mask of mcfe error serializer3 unsupported format.  "
bitfld.long 0x00 19. " Mask mcfe error serializer3 output overflow  , Mcfe: Mask of mcfe error serializer3 output overflow.  "
textline "                 "
bitfld.long 0x00 20. " Mask mcfe error fifo in crc3 fifo crc mismatch  , Mcfe: Mask of mcfe error fifo in crc3 fifo crc mismatch.  "
bitfld.long 0x00 21. " Mask mcfe error fifo in crc3 crc fifo overflow  , Mcfe: Mask of mcfe error fifo in crc3 crc fifo overflow.  "
bitfld.long 0x00 22. " Mask mcfe error axi writer3 bresp  , Mcfe: Mask of mcfe error axi writer3 bresp.  "
bitfld.long 0x00 23. " Mask mcfe error axi writer3 awmaxwait  , Mcfe: Mask of mcfe error axi writer3 awmaxwait.  "
textline "                 "
bitfld.long 0x00 24. " Mask mcfe error axi writer3 wmaxwait  , Mcfe: Mask of mcfe error axi writer3 wmaxwait.  "
bitfld.long 0x00 25. " Mask mcfe error axi writer3 wxact ostand  , Mcfe: Mask of mcfe error axi writer3 wxact ostand.  "
bitfld.long 0x00 26. " Mask mcfe error axi writer3 user intfc  , Mcfe: Mask of mcfe error axi writer3 user intfc.  "
bitfld.long 0x00 27. " Mask mcfe error axi writer3 fifo fail full  , Mcfe: Mask of mcfe error axi writer3 fifo fail full.  "
textline "                 "
bitfld.long 0x00 28. " Mask mcfe error axi writer3 fifo fail empty  , Mcfe: Mask of mcfe error axi writer3 fifo fail empty.  "
bitfld.long 0x00 29. " Mask mcfe error axi writer3 frame dropped  , Mcfe: Mask of mcfe error axi writer3 frame dropped.  "
bitfld.long 0x00 30. " Mask mcfe error fb manager3 internal  , Mcfe: Mask of mcfe error fb manager3 internal.  "
bitfld.long 0x00 31. " Mask mcfe error serializer4 unsupported format  , Mcfe: Mask of mcfe error serializer4 unsupported format.  "
group.long 0x1008++0x3
line.long 0x00 "0x1008"
textline "                 "
bitfld.long 0x00 0. " Mask mcfe error serializer4 output overflow  , Mcfe: Mask of mcfe error serializer4 output overflow.  "
bitfld.long 0x00 1. " Mask mcfe error fifo in crc4 fifo crc mismatch  , Mcfe: Mask of mcfe error fifo in crc4 fifo crc mismatch.  "
bitfld.long 0x00 2. " Mask mcfe error fifo in crc4 crc fifo overflow  , Mcfe: Mask of mcfe error fifo in crc4 crc fifo overflow.  "
bitfld.long 0x00 3. " Mask mcfe error axi writer4 bresp  , Mcfe: Mask of mcfe error axi writer4 bresp.  "
textline "                 "
bitfld.long 0x00 4. " Mask mcfe error axi writer4 awmaxwait  , Mcfe: Mask of mcfe error axi writer4 awmaxwait.  "
bitfld.long 0x00 5. " Mask mcfe error axi writer4 wmaxwait  , Mcfe: Mask of mcfe error axi writer4 wmaxwait.  "
bitfld.long 0x00 6. " Mask mcfe error axi writer4 wxact ostand  , Mcfe: Mask of mcfe error axi writer4 wxact ostand.  "
bitfld.long 0x00 7. " Mask mcfe error axi writer4 user intfc  , Mcfe: Mask of mcfe error axi writer4 user intfc.  "
textline "                 "
bitfld.long 0x00 8. " Mask mcfe error axi writer4 fifo fail full  , Mcfe: Mask of mcfe error axi writer4 fifo fail full.  "
bitfld.long 0x00 9. " Mask mcfe error axi writer4 fifo fail empty  , Mcfe: Mask of mcfe error axi writer4 fifo fail empty.  "
bitfld.long 0x00 10. " Mask mcfe error axi writer4 frame dropped  , Mcfe: Mask of mcfe error axi writer4 frame dropped.  "
bitfld.long 0x00 11. " Mask mcfe error fb manager4 internal  , Mcfe: Mask of mcfe error fb manager4 internal.  "
textline "                 "
bitfld.long 0x00 12. " Mask mcfe error axi reader1 armaxwait  , Mcfe: Mask of mcfe error axi reader1 armaxwait.  "
bitfld.long 0x00 13. " Mask mcfe error axi reader1 rresp  , Mcfe: Mask of mcfe error axi reader1 rresp.  "
bitfld.long 0x00 14. " Mask mcfe error axi reader1 rxnfr ostand  , Mcfe: Mask of mcfe error axi reader1 rxnfr ostand.  "
bitfld.long 0x00 15. " Mask mcfe error axi reader1 user intfc  , Mcfe: Mask of mcfe error axi reader1 user intfc.  "
textline "                 "
bitfld.long 0x00 16. " Mask mcfe error axi reader1 fifo fail full  , Mcfe: Mask of mcfe error axi reader1 fifo fail full.  "
bitfld.long 0x00 17. " Mask mcfe error axi reader1 fifo fail empty  , Mcfe: Mask of mcfe error axi reader1 fifo fail empty.  "
bitfld.long 0x00 18. " Mask mcfe error fifo out crc1 fifo crc mismatch  , Mcfe: Mask of mcfe error fifo out crc1 fifo crc mismatch.  "
bitfld.long 0x00 19. " Mask mcfe error fifo out crc1 crc fifo overflow  , Mcfe: Mask of mcfe error fifo out crc1 crc fifo overflow.  "
textline "                 "
bitfld.long 0x00 20. " Mask mcfe error deserializer1 unsupported format  , Mcfe: Mask of mcfe error deserializer1 unsupported format.  "
bitfld.long 0x00 21. " Mask mcfe error deserializer1 geometry  , Mcfe: Mask of mcfe error deserializer1 geometry.  "
bitfld.long 0x00 22. " Mask mcfe error deserializer1 underrun  , Mcfe: Mask of mcfe error deserializer1 underrun.  "
bitfld.long 0x00 23. " Mask mcfe error axi reader2 armaxwait  , Mcfe: Mask of mcfe error axi reader2 armaxwait.  "
textline "                 "
bitfld.long 0x00 24. " Mask mcfe error axi reader2 rresp  , Mcfe: Mask of mcfe error axi reader2 rresp.  "
bitfld.long 0x00 25. " Mask mcfe error axi reader2 rxnfr ostand  , Mcfe: Mask of mcfe error axi reader2 rxnfr ostand.  "
bitfld.long 0x00 26. " Mask mcfe error axi reader2 user intfc  , Mcfe: Mask of mcfe error axi reader2 user intfc.  "
bitfld.long 0x00 27. " Mask mcfe error axi reader2 fifo fail full  , Mcfe: Mask of mcfe error axi reader2 fifo fail full.  "
textline "                 "
bitfld.long 0x00 28. " Mask mcfe error axi reader2 fifo fail empty  , Mcfe: Mask of mcfe error axi reader2 fifo fail empty.  "
bitfld.long 0x00 29. " Mask mcfe error fifo out crc2 fifo crc mismatch  , Mcfe: Mask of mcfe error fifo out crc2 fifo crc mismatch.  "
bitfld.long 0x00 30. " Mask mcfe error fifo out crc2 crc fifo overflow  , Mcfe: Mask of mcfe error fifo out crc2 crc fifo overflow.  "
bitfld.long 0x00 31. " Mask mcfe error deserializer2 unsupported format  , Mcfe: Mask of mcfe error deserializer2 unsupported format.  "
group.long 0x100c++0x3
line.long 0x00 "0x100c"
textline "                 "
bitfld.long 0x00 0. " Mask mcfe error deserializer2 geometry  , Mcfe: Mask of mcfe error deserializer2 geometry.  "
bitfld.long 0x00 1. " Mask mcfe error deserializer2 underrun  , Mcfe: Mask of mcfe error deserializer2 underrun.  "
bitfld.long 0x00 2. " Mask mcfe error axi reader3 armaxwait  , Mcfe: Mask of mcfe error axi reader3 armaxwait.  "
bitfld.long 0x00 3. " Mask mcfe error axi reader3 rresp  , Mcfe: Mask of mcfe error axi reader3 rresp.  "
textline "                 "
bitfld.long 0x00 4. " Mask mcfe error axi reader3 rxnfr ostand  , Mcfe: Mask of mcfe error axi reader3 rxnfr ostand.  "
bitfld.long 0x00 5. " Mask mcfe error axi reader3 user intfc  , Mcfe: Mask of mcfe error axi reader3 user intfc.  "
bitfld.long 0x00 6. " Mask mcfe error axi reader3 fifo fail full  , Mcfe: Mask of mcfe error axi reader3 fifo fail full.  "
bitfld.long 0x00 7. " Mask mcfe error axi reader3 fifo fail empty  , Mcfe: Mask of mcfe error axi reader3 fifo fail empty.  "
textline "                 "
bitfld.long 0x00 8. " Mask mcfe error fifo out crc3 fifo crc mismatch  , Mcfe: Mask of mcfe error fifo out crc3 fifo crc mismatch.  "
bitfld.long 0x00 9. " Mask mcfe error fifo out crc3 crc fifo overflow  , Mcfe: Mask of mcfe error fifo out crc3 crc fifo overflow.  "
bitfld.long 0x00 10. " Mask mcfe error deserializer3 unsupported format  , Mcfe: Mask of mcfe error deserializer3 unsupported format.  "
bitfld.long 0x00 11. " Mask mcfe error deserializer3 geometry  , Mcfe: Mask of mcfe error deserializer3 geometry.  "
textline "                 "
bitfld.long 0x00 12. " Mask mcfe error deserializer3 underrun  , Mcfe: Mask of mcfe error deserializer3 underrun.  "
bitfld.long 0x00 13. " Mask mcfe error axi reader4 armaxwait  , Mcfe: Mask of mcfe error axi reader4 armaxwait.  "
bitfld.long 0x00 14. " Mask mcfe error axi reader4 rresp  , Mcfe: Mask of mcfe error axi reader4 rresp.  "
bitfld.long 0x00 15. " Mask mcfe error axi reader4 rxnfr ostand  , Mcfe: Mask of mcfe error axi reader4 rxnfr ostand.  "
textline "                 "
bitfld.long 0x00 16. " Mask mcfe error axi reader4 user intfc  , Mcfe: Mask of mcfe error axi reader4 user intfc.  "
bitfld.long 0x00 17. " Mask mcfe error axi reader4 fifo fail full  , Mcfe: Mask of mcfe error axi reader4 fifo fail full.  "
bitfld.long 0x00 18. " Mask mcfe error axi reader4 fifo fail empty  , Mcfe: Mask of mcfe error axi reader4 fifo fail empty.  "
bitfld.long 0x00 19. " Mask mcfe error fifo out crc4 fifo crc mismatch  , Mcfe: Mask of mcfe error fifo out crc4 fifo crc mismatch.  "
textline "                 "
bitfld.long 0x00 20. " Mask mcfe error fifo out crc4 crc fifo overflow  , Mcfe: Mask of mcfe error fifo out crc4 crc fifo overflow.  "
bitfld.long 0x00 21. " Mask mcfe error deserializer4 unsupported format  , Mcfe: Mask of mcfe error deserializer4 unsupported format.  "
bitfld.long 0x00 22. " Mask mcfe error deserializer4 geometry  , Mcfe: Mask of mcfe error deserializer4 geometry.  "
bitfld.long 0x00 23. " Mask mcfe error deserializer4 underrun  , Mcfe: Mask of mcfe error deserializer4 underrun.  "
textline "                 "
bitfld.long 0x00 24. " Mask mcfe error synchronizer framing  , Mcfe: Mask of mcfe error synchronizer framing.  "
bitfld.long 0x00 25. " Mask mcfe error scheduler buffer collision  , Mcfe: Mask of mcfe error scheduler buffer collision.  "
hexmask.long.byte 0x00 26.--29. 1. " Mask mcfe error scheduler input statistics overrun  ,Mcfe: Mask of mcfe error scheduler input statistics overrun."
textline "                 "
bitfld.long 0x00 30. " Mask mcfe error scheduler config  , Mcfe: Mask of mcfe error scheduler config.  "
bitfld.long 0x00 31. " Mask mcfe error scheduler internal error  , Mcfe: Mask of mcfe error scheduler internal error.  "
group.long 0x1010++0x3
line.long 0x00 "0x1010"
bitfld.long 0x00 0. " Mask mcfe error scheduler input data width mismatch  , Mcfe: Mask of mcfe error scheduler input data width mismatch.  "
bitfld.long 0x00 1. " Mask mcfe error scheduler read geometry mismatch  , Mcfe: Mask of mcfe error scheduler read geometry mismatch.  "
hexmask.long.byte 0x00 2.--7. 1. " Mask mcfe error scoreboard access  ,Mcfe: Mask of mcfe error scoreboard access."
hexmask.long.byte 0x00 8.--13. 1. " Mask mcfe error scoreboard invalid command  ,Mcfe: Mask of mcfe error scoreboard invalid command."
textline "                 "
bitfld.long 0x00 14. " Mask mcfe error scoreboard buffer collision  , Mcfe: Mask of mcfe error scoreboard buffer collision.  "
hexmask.long.word 0x00 15.--20. 1. " Mask mcfe error scoreboard crc mismatch  ,Mcfe: Mask of mcfe error scoreboard crc mismatch."
textline "                 "
bitfld.long 0x00 21. " Mask mcfe error buffer config buffer access  , Mcfe: Mask of mcfe error buffer config buffer access.  "
bitfld.long 0x00 22. " Mask mcfe error buffer config internal fault  , Mcfe: Mask of mcfe error buffer config internal fault.  "
bitfld.long 0x00 23. " Mask mcfe error buffer config config crc mismatch  , Mcfe: Mask of mcfe error buffer config config crc mismatch.  "
bitfld.long 0x00 24. " Mask mcfe error config dma armaxwait  , Mcfe: Mask of mcfe error config dma armaxwait.  "
textline "                 "
bitfld.long 0x00 25. " Mask mcfe error config dma rresp  , Mcfe: Mask of mcfe error config dma rresp.  "
bitfld.long 0x00 26. " Mask mcfe error config dma rxnfr ostand  , Mcfe: Mask of mcfe error config dma rxnfr ostand.  "
bitfld.long 0x00 27. " Mask mcfe error config dma user intfc  , Mcfe: Mask of mcfe error config dma user intfc.  "
bitfld.long 0x00 28. " Mask mcfe error config dma rfifo fail full  , Mcfe: Mask of mcfe error config dma rfifo fail full.  "
textline "                 "
bitfld.long 0x00 29. " Mask mcfe error config dma rfifo fail empty  , Mcfe: Mask of mcfe error config dma rfifo fail empty.  "
bitfld.long 0x00 30. " Mask mcfe error config dma bresp  , Mcfe: Mask of mcfe error config dma bresp.  "
bitfld.long 0x00 31. " Mask mcfe error config dma awmaxwait  , Mcfe: Mask of mcfe error config dma awmaxwait.  "
group.long 0x1014++0x3
line.long 0x00 "0x1014"
bitfld.long 0x00 0. " Mask mcfe error config dma wmaxwait  , Mcfe: Mask of mcfe error config dma wmaxwait.  "
textline "                 "
bitfld.long 0x00 1. " Mask mcfe error config dma wxact ostand  , Mcfe: Mask of mcfe error config dma wxact ostand.  "
bitfld.long 0x00 2. " Mask mcfe error config dma wfifo fail full  , Mcfe: Mask of mcfe error config dma wfifo fail full.  "
bitfld.long 0x00 3. " Mask mcfe error config dma wfifo fail empty  , Mcfe: Mask of mcfe error config dma wfifo fail empty.  "
bitfld.long 0x00 4. " Mask mcfe error config dma read overflow  , Mcfe: Mask of mcfe error config dma read overflow.  "
textline "                 "
bitfld.long 0x00 5. " Mask mcfe error config dma axi overread  , Mcfe: Mask of mcfe error config dma axi overread.  "
bitfld.long 0x00 6. " Mask mcfe error config dma axi overwrite  , Mcfe: Mask of mcfe error config dma axi overwrite.  "
bitfld.long 0x00 7. " Mask mcfe error config dma internal  , Mcfe: Mask of mcfe error config dma internal.  "
bitfld.long 0x00 8. " Mask mcbe error serializer1 unsupported format  , Mcbe: Mask of mcbe error serializer1 unsupported format.  "
textline "                 "
bitfld.long 0x00 9. " Mask mcbe error serializer1 output overflow  , Mcbe: Mask of mcbe error serializer1 output overflow.  "
bitfld.long 0x00 10. " Mask mcbe error fifo in crc1 fifo crc mismatch  , Mcbe: Mask of mcbe error fifo in crc1 fifo crc mismatch.  "
bitfld.long 0x00 11. " Mask mcbe error fifo in crc1 crc fifo overflow  , Mcbe: Mask of mcbe error fifo in crc1 crc fifo overflow.  "
bitfld.long 0x00 12. " Mask mcbe error axi writer1 bresp  , Mcbe: Mask of mcbe error axi writer1 bresp.  "
textline "                 "
bitfld.long 0x00 13. " Mask mcbe error axi writer1 awmaxwait  , Mcbe: Mask of mcbe error axi writer1 awmaxwait.  "
bitfld.long 0x00 14. " Mask mcbe error axi writer1 wmaxwait  , Mcbe: Mask of mcbe error axi writer1 wmaxwait.  "
bitfld.long 0x00 15. " Mask mcbe error axi writer1 wxact ostand  , Mcbe: Mask of mcbe error axi writer1 wxact ostand.  "
bitfld.long 0x00 16. " Mask mcbe error axi writer1 user intfc  , Mcbe: Mask of mcbe error axi writer1 user intfc.  "
textline "                 "
bitfld.long 0x00 17. " Mask mcbe error axi writer1 fifo fail full  , Mcbe: Mask of mcbe error axi writer1 fifo fail full.  "
bitfld.long 0x00 18. " Mask mcbe error axi writer1 fifo fail empty  , Mcbe: Mask of mcbe error axi writer1 fifo fail empty.  "
bitfld.long 0x00 19. " Mask mcbe error axi writer1 frame dropped  , Mcbe: Mask of mcbe error axi writer1 frame dropped.  "
bitfld.long 0x00 20. " Mask mcbe error fb manager1 internal  , Mcbe: Mask of mcbe error fb manager1 internal.  "
textline "                 "
bitfld.long 0x00 21. " Mask mcbe error serializer2 unsupported format  , Mcbe: Mask of mcbe error serializer2 unsupported format.  "
bitfld.long 0x00 22. " Mask mcbe error serializer2 output overflow  , Mcbe: Mask of mcbe error serializer2 output overflow.  "
bitfld.long 0x00 23. " Mask mcbe error fifo in crc2 fifo crc mismatch  , Mcbe: Mask of mcbe error fifo in crc2 fifo crc mismatch.  "
bitfld.long 0x00 24. " Mask mcbe error fifo in crc2 crc fifo overflow  , Mcbe: Mask of mcbe error fifo in crc2 crc fifo overflow.  "
textline "                 "
bitfld.long 0x00 25. " Mask mcbe error axi writer2 bresp  , Mcbe: Mask of mcbe error axi writer2 bresp.  "
bitfld.long 0x00 26. " Mask mcbe error axi writer2 awmaxwait  , Mcbe: Mask of mcbe error axi writer2 awmaxwait.  "
bitfld.long 0x00 27. " Mask mcbe error axi writer2 wmaxwait  , Mcbe: Mask of mcbe error axi writer2 wmaxwait.  "
bitfld.long 0x00 28. " Mask mcbe error axi writer2 wxact ostand  , Mcbe: Mask of mcbe error axi writer2 wxact ostand.  "
textline "                 "
bitfld.long 0x00 29. " Mask mcbe error axi writer2 user intfc  , Mcbe: Mask of mcbe error axi writer2 user intfc.  "
bitfld.long 0x00 30. " Mask mcbe error axi writer2 fifo fail full  , Mcbe: Mask of mcbe error axi writer2 fifo fail full.  "
bitfld.long 0x00 31. " Mask mcbe error axi writer2 fifo fail empty  , Mcbe: Mask of mcbe error axi writer2 fifo fail empty.  "
group.long 0x1018++0x3
line.long 0x00 "0x1018"
bitfld.long 0x00 0. " Mask mcbe error axi writer2 frame dropped  , Mcbe: Mask of mcbe error axi writer2 frame dropped.  "
textline "                 "
bitfld.long 0x00 1. " Mask mcbe error fb manager2 internal  , Mcbe: Mask of mcbe error fb manager2 internal.  "
bitfld.long 0x00 2. " Mask mcbe error serializer3 unsupported format  , Mcbe: Mask of mcbe error serializer3 unsupported format.  "
bitfld.long 0x00 3. " Mask mcbe error serializer3 output overflow  , Mcbe: Mask of mcbe error serializer3 output overflow.  "
bitfld.long 0x00 4. " Mask mcbe error fifo in crc3 fifo crc mismatch  , Mcbe: Mask of mcbe error fifo in crc3 fifo crc mismatch.  "
textline "                 "
bitfld.long 0x00 5. " Mask mcbe error fifo in crc3 crc fifo overflow  , Mcbe: Mask of mcbe error fifo in crc3 crc fifo overflow.  "
bitfld.long 0x00 6. " Mask mcbe error axi writer3 bresp  , Mcbe: Mask of mcbe error axi writer3 bresp.  "
bitfld.long 0x00 7. " Mask mcbe error axi writer3 awmaxwait  , Mcbe: Mask of mcbe error axi writer3 awmaxwait.  "
bitfld.long 0x00 8. " Mask mcbe error axi writer3 wmaxwait  , Mcbe: Mask of mcbe error axi writer3 wmaxwait.  "
textline "                 "
bitfld.long 0x00 9. " Mask mcbe error axi writer3 wxact ostand  , Mcbe: Mask of mcbe error axi writer3 wxact ostand.  "
bitfld.long 0x00 10. " Mask mcbe error axi writer3 user intfc  , Mcbe: Mask of mcbe error axi writer3 user intfc.  "
bitfld.long 0x00 11. " Mask mcbe error axi writer3 fifo fail full  , Mcbe: Mask of mcbe error axi writer3 fifo fail full.  "
bitfld.long 0x00 12. " Mask mcbe error axi writer3 fifo fail empty  , Mcbe: Mask of mcbe error axi writer3 fifo fail empty.  "
textline "                 "
bitfld.long 0x00 13. " Mask mcbe error axi writer3 frame dropped  , Mcbe: Mask of mcbe error axi writer3 frame dropped.  "
bitfld.long 0x00 14. " Mask mcbe error fb manager3 internal  , Mcbe: Mask of mcbe error fb manager3 internal.  "
bitfld.long 0x00 15. " Mask mcbe error serializer4 unsupported format  , Mcbe: Mask of mcbe error serializer4 unsupported format.  "
bitfld.long 0x00 16. " Mask mcbe error serializer4 output overflow  , Mcbe: Mask of mcbe error serializer4 output overflow.  "
textline "                 "
bitfld.long 0x00 17. " Mask mcbe error fifo in crc4 fifo crc mismatch  , Mcbe: Mask of mcbe error fifo in crc4 fifo crc mismatch.  "
bitfld.long 0x00 18. " Mask mcbe error fifo in crc4 crc fifo overflow  , Mcbe: Mask of mcbe error fifo in crc4 crc fifo overflow.  "
bitfld.long 0x00 19. " Mask mcbe error axi writer4 bresp  , Mcbe: Mask of mcbe error axi writer4 bresp.  "
bitfld.long 0x00 20. " Mask mcbe error axi writer4 awmaxwait  , Mcbe: Mask of mcbe error axi writer4 awmaxwait.  "
textline "                 "
bitfld.long 0x00 21. " Mask mcbe error axi writer4 wmaxwait  , Mcbe: Mask of mcbe error axi writer4 wmaxwait.  "
bitfld.long 0x00 22. " Mask mcbe error axi writer4 wxact ostand  , Mcbe: Mask of mcbe error axi writer4 wxact ostand.  "
bitfld.long 0x00 23. " Mask mcbe error axi writer4 user intfc  , Mcbe: Mask of mcbe error axi writer4 user intfc.  "
bitfld.long 0x00 24. " Mask mcbe error axi writer4 fifo fail full  , Mcbe: Mask of mcbe error axi writer4 fifo fail full.  "
textline "                 "
bitfld.long 0x00 25. " Mask mcbe error axi writer4 fifo fail empty  , Mcbe: Mask of mcbe error axi writer4 fifo fail empty.  "
bitfld.long 0x00 26. " Mask mcbe error axi writer4 frame dropped  , Mcbe: Mask of mcbe error axi writer4 frame dropped.  "
bitfld.long 0x00 27. " Mask mcbe error fb manager4 internal  , Mcbe: Mask of mcbe error fb manager4 internal.  "
hexmask.long.word 0x00 28.--31. 1. " Mask mcbe error scoreboard access  ,Mcbe: Mask of mcbe error scoreboard access."
group.long 0x101c++0x3
line.long 0x00 "0x101c"
hexmask.long.byte 0x00 1.--5. 1. " Mask mcbe error scoreboard invalid command  ,Mcbe: Mask of mcbe error scoreboard invalid command."
textline "                 "
bitfld.long 0x00 6. " Mask mcbe error scoreboard buffer collision  , Mcbe: Mask of mcbe error scoreboard buffer collision.  "
hexmask.long.word 0x00 7.--11. 1. " Mask mcbe error scoreboard crc mismatch  ,Mcbe: Mask of mcbe error scoreboard crc mismatch."
textline "                 "
bitfld.long 0x00 12. " Mask mcbe error buffer config buffer access  , Mcbe: Mask of mcbe error buffer config buffer access.  "
bitfld.long 0x00 13. " Mask mcbe error buffer config internal fault  , Mcbe: Mask of mcbe error buffer config internal fault.  "
bitfld.long 0x00 14. " Mask mcbe error buffer config config crc mismatch  , Mcbe: Mask of mcbe error buffer config config crc mismatch.  "
bitfld.long 0x00 15. " Mask stream crossbar error invalid configuration  , Stream crossbar: Mask of stream crossbar error invalid configuration.  "
textline "                 "
bitfld.long 0x00 16. " Mask frame check sensor 1 fault o  , Frame check sensor 1: Mask of frame check sensor 1 fault o.  "
bitfld.long 0x00 17. " Mask frame repeat sensor 1 repeating frame warning  , Frame repeat sensor 1: Mask of frame repeat sensor 1 repeating frame warning.  "
bitfld.long 0x00 18. " Mask frame repeat sensor 1 repeating frame error  , Frame repeat sensor 1: Mask of frame repeat sensor 1 repeating frame error.  "
bitfld.long 0x00 19. " Mask metering hist 1 config checker config error  , Metering hist 1: Mask of metering hist 1 config checker config error.  "
textline "                 "
bitfld.long 0x00 20. " Mask frame check sensor 2 fault o  , Frame check sensor 2: Mask of frame check sensor 2 fault o.  "
bitfld.long 0x00 21. " Mask frame repeat sensor 2 repeating frame warning  , Frame repeat sensor 2: Mask of frame repeat sensor 2 repeating frame warning.  "
bitfld.long 0x00 22. " Mask frame repeat sensor 2 repeating frame error  , Frame repeat sensor 2: Mask of frame repeat sensor 2 repeating frame error.  "
bitfld.long 0x00 23. " Mask metering hist 2 config checker config error  , Metering hist 2: Mask of metering hist 2 config checker config error.  "
textline "                 "
bitfld.long 0x00 24. " Mask frame check sensor 3 fault o  , Frame check sensor 3: Mask of frame check sensor 3 fault o.  "
bitfld.long 0x00 25. " Mask frame repeat sensor 3 repeating frame warning  , Frame repeat sensor 3: Mask of frame repeat sensor 3 repeating frame warning.  "
bitfld.long 0x00 26. " Mask frame repeat sensor 3 repeating frame error  , Frame repeat sensor 3: Mask of frame repeat sensor 3 repeating frame error.  "
bitfld.long 0x00 27. " Mask metering hist 3 config checker config error  , Metering hist 3: Mask of metering hist 3 config checker config error.  "
textline "                 "
bitfld.long 0x00 28. " Mask frame check sensor 4 fault o  , Frame check sensor 4: Mask of frame check sensor 4 fault o.  "
bitfld.long 0x00 29. " Mask frame repeat sensor 4 repeating frame warning  , Frame repeat sensor 4: Mask of frame repeat sensor 4 repeating frame warning.  "
bitfld.long 0x00 30. " Mask frame repeat sensor 4 repeating frame error  , Frame repeat sensor 4: Mask of frame repeat sensor 4 repeating frame error.  "
bitfld.long 0x00 31. " Mask metering hist 4 config checker config error  , Metering hist 4: Mask of metering hist 4 config checker config error.  "
group.long 0x1020++0x3
line.long 0x00 "0x1020"
textline "                 "
bitfld.long 0x00 0. " Mask frame check isp fault o  , Frame check isp: Mask of frame check isp fault o.  "
bitfld.long 0x00 1. " Mask input formatter parameter error  , Input formatter: Mask of input formatter parameter error.  "
bitfld.long 0x00 2. " Mask frame stitch crc data o fault crc mismatch  , Frame stitch: Mask of frame stitch crc data o fault crc mismatch.  "
bitfld.long 0x00 3. " Mask frame stitch bist sequencer error test timeout  , Frame stitch: Mask of frame stitch bist sequencer error test timeout.  "
textline "                 "
bitfld.long 0x00 4. " Mask frame stitch bist sequencer error test collision  , Frame stitch: Mask of frame stitch bist sequencer error test collision.  "
bitfld.long 0x00 5. " Mask frame stitch config checker config error  , Frame stitch: Mask of frame stitch config checker config error.  "
bitfld.long 0x00 6. " Mask fstitch1 delay line check delay line error  , Fstitch1 delay line check: Mask of fstitch1 delay line check delay line error.  "
bitfld.long 0x00 7. " Mask fstitch2 delay line check delay line error  , Fstitch2 delay line check: Mask of fstitch2 delay line check delay line error.  "
textline "                 "
bitfld.long 0x00 8. " Mask fstitch3 delay line check delay line error  , Fstitch3 delay line check: Mask of fstitch3 delay line check delay line error.  "
bitfld.long 0x00 9. " Mask frame repeat isp repeating frame warning  , Frame repeat isp: Mask of frame repeat isp repeating frame warning.  "
bitfld.long 0x00 10. " Mask frame repeat isp repeating frame error  , Frame repeat isp: Mask of frame repeat isp repeating frame error.  "
bitfld.long 0x00 11. " Mask gamma fedl crc data o fault crc mismatch  , Gamma fedl: Mask of gamma fedl crc data o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 12. " Mask gamma fedl bist sequencer error test timeout  , Gamma fedl: Mask of gamma fedl bist sequencer error test timeout.  "
bitfld.long 0x00 13. " Mask gamma fedl bist sequencer error test collision  , Gamma fedl: Mask of gamma fedl bist sequencer error test collision.  "
bitfld.long 0x00 14. " Mask gamma fedl config checker config error  , Gamma fedl: Mask of gamma fedl config checker config error.  "
bitfld.long 0x00 15. " Mask roi hist 1 config checker config error  , Roi hist 1: Mask of roi hist 1 config checker config error.  "
textline "                 "
bitfld.long 0x00 16. " Mask roi hist 2 config checker config error  , Roi hist 2: Mask of roi hist 2 config checker config error.  "
bitfld.long 0x00 17. " Mask roi hist 3 config checker config error  , Roi hist 3: Mask of roi hist 3 config checker config error.  "
bitfld.long 0x00 18. " Mask roi hist 4 config checker config error  , Roi hist 4: Mask of roi hist 4 config checker config error.  "
bitfld.long 0x00 19. " Mask raw frontend crc data o fault crc mismatch  , Raw frontend: Mask of raw frontend crc data o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 20. " Mask raw frontend crc hp median fault crc mismatch  , Raw frontend: Mask of raw frontend crc hp median fault crc mismatch.  "
bitfld.long 0x00 21. " Mask raw frontend crc hotpixel marker fault crc mismatch  , Raw frontend: Mask of raw frontend crc hotpixel marker fault crc mismatch.  "
bitfld.long 0x00 22. " Mask raw frontend bist sequencer error test timeout  , Raw frontend: Mask of raw frontend bist sequencer error test timeout.  "
bitfld.long 0x00 23. " Mask raw frontend bist sequencer error test collision  , Raw frontend: Mask of raw frontend bist sequencer error test collision.  "
textline "                 "
bitfld.long 0x00 24. " Mask raw frontend config checker config error  , Raw frontend: Mask of raw frontend config checker config error.  "
bitfld.long 0x00 25. " Mask defect pixel config checker config error  , Defect pixel: Mask of defect pixel config checker config error.  "
bitfld.long 0x00 26. " Mask sinter crc vdata o fault crc mismatch  , Sinter: Mask of sinter crc vdata o fault crc mismatch.  "
bitfld.long 0x00 27. " Mask sinter bist sequencer error test timeout  , Sinter: Mask of sinter bist sequencer error test timeout.  "
textline "                 "
bitfld.long 0x00 28. " Mask sinter bist sequencer error test collision  , Sinter: Mask of sinter bist sequencer error test collision.  "
bitfld.long 0x00 29. " Mask sinter config checker config error  , Sinter: Mask of sinter config checker config error.  "
bitfld.long 0x00 30. " Mask ca correction delay line checker delay line error  , Ca correction delay line checker: Mask of ca correction delay line checker delay line error.  "
bitfld.long 0x00 31. " Mask ca correction error range  , Ca correction: Mask of ca correction error range.  "
group.long 0x1024++0x3
line.long 0x00 "0x1024"
textline "                 "
bitfld.long 0x00 0. " Mask ca correction error cache  , Ca correction: Mask of ca correction error cache.  "
bitfld.long 0x00 1. " Mask ca correction error address  , Ca correction: Mask of ca correction error address.  "
bitfld.long 0x00 2. " Mask ca correction config checker config error  , Ca correction: Mask of ca correction config checker config error.  "
bitfld.long 0x00 3. " Mask gamma bedl crc data o fault crc mismatch  , Gamma bedl: Mask of gamma bedl crc data o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 4. " Mask gamma bedl bist sequencer error test timeout  , Gamma bedl: Mask of gamma bedl bist sequencer error test timeout.  "
bitfld.long 0x00 5. " Mask gamma bedl bist sequencer error test collision  , Gamma bedl: Mask of gamma bedl bist sequencer error test collision.  "
bitfld.long 0x00 6. " Mask gamma bedl config checker config error  , Gamma bedl: Mask of gamma bedl config checker config error.  "
bitfld.long 0x00 7. " Mask radial shading crc data o fault crc mismatch  , Radial shading: Mask of radial shading crc data o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 8. " Mask radial shading bist sequencer error test timeout  , Radial shading: Mask of radial shading bist sequencer error test timeout.  "
bitfld.long 0x00 9. " Mask radial shading bist sequencer error test collision  , Radial shading: Mask of radial shading bist sequencer error test collision.  "
bitfld.long 0x00 10. " Mask radial shading config checker config error  , Radial shading: Mask of radial shading config checker config error.  "
bitfld.long 0x00 11. " Mask mesh shading config checker config error  , Mesh shading: Mask of mesh shading config checker config error.  "
textline "                 "
bitfld.long 0x00 12. " Mask iridix crc data o fault crc mismatch  , Iridix: Mask of iridix crc data o fault crc mismatch.  "
bitfld.long 0x00 13. " Mask iridix bist sequencer error test timeout  , Iridix: Mask of iridix bist sequencer error test timeout.  "
bitfld.long 0x00 14. " Mask iridix bist sequencer error test collision  , Iridix: Mask of iridix bist sequencer error test collision.  "
bitfld.long 0x00 15. " Mask iridix config checker config error  , Iridix: Mask of iridix config checker config error.  "
textline "                 "
bitfld.long 0x00 16. " Mask antifog hist config checker config error  , Antifog hist: Mask of antifog hist config checker config error.  "
bitfld.long 0x00 17. " Mask demosaic delay line checker delay line error  , Demosaic delay line checker: Mask of demosaic delay line checker delay line error.  "
bitfld.long 0x00 18. " Mask demosaic rccc crc vdata1 rc r o fault crc mismatch  , Demosaic rccc: Mask of demosaic rccc crc vdata1 rc r o fault crc mismatch.  "
bitfld.long 0x00 19. " Mask demosaic rccc crc vdata2 rc c o fault crc mismatch  , Demosaic rccc: Mask of demosaic rccc crc vdata2 rc c o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 20. " Mask demosaic rccc bist sequencer error test timeout  , Demosaic rccc: Mask of demosaic rccc bist sequencer error test timeout.  "
bitfld.long 0x00 21. " Mask demosaic rccc bist sequencer error test collision  , Demosaic rccc: Mask of demosaic rccc bist sequencer error test collision.  "
bitfld.long 0x00 22. " Mask demosaic rccc config checker config error  , Demosaic rccc: Mask of demosaic rccc config checker config error.  "
bitfld.long 0x00 23. " Mask demosaic crc red o fault crc mismatch  , Demosaic: Mask of demosaic crc red o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 24. " Mask demosaic crc grn o fault crc mismatch  , Demosaic: Mask of demosaic crc grn o fault crc mismatch.  "
bitfld.long 0x00 25. " Mask demosaic crc blu o fault crc mismatch  , Demosaic: Mask of demosaic crc blu o fault crc mismatch.  "
bitfld.long 0x00 26. " Mask demosaic crc mask sad o fault crc mismatch  , Demosaic: Mask of demosaic crc mask sad o fault crc mismatch.  "
bitfld.long 0x00 27. " Mask demosaic bist sequencer error test timeout  , Demosaic: Mask of demosaic bist sequencer error test timeout.  "
textline "                 "
bitfld.long 0x00 28. " Mask demosaic bist sequencer error test collision  , Demosaic: Mask of demosaic bist sequencer error test collision.  "
bitfld.long 0x00 29. " Mask demosaic config checker config error  , Demosaic: Mask of demosaic config checker config error.  "
bitfld.long 0x00 30. " Mask demosaic rgbir cfg calc fault o  , Demosaic rgbir: Mask of demosaic rgbir cfg calc fault o.  "
bitfld.long 0x00 31. " Mask demosaic rgbir demosaic rgbir cfg calc fault o  , Demosaic rgbir: Mask of demosaic rgbir demosaic rgbir cfg calc fault o.  "
group.long 0x1028++0x3
line.long 0x00 "0x1028"
textline "                 "
bitfld.long 0x00 0. " Mask demosaic rgbir crc rplane o fault crc mismatch  , Demosaic rgbir: Mask of demosaic rgbir crc rplane o fault crc mismatch.  "
bitfld.long 0x00 1. " Mask demosaic rgbir crc gplane o fault crc mismatch  , Demosaic rgbir: Mask of demosaic rgbir crc gplane o fault crc mismatch.  "
bitfld.long 0x00 2. " Mask demosaic rgbir crc bplane o fault crc mismatch  , Demosaic rgbir: Mask of demosaic rgbir crc bplane o fault crc mismatch.  "
bitfld.long 0x00 3. " Mask demosaic rgbir crc iplane o fault crc mismatch  , Demosaic rgbir: Mask of demosaic rgbir crc iplane o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 4. " Mask demosaic rgbir crc declip data o fault crc mismatch  , Demosaic rgbir: Mask of demosaic rgbir crc declip data o fault crc mismatch.  "
bitfld.long 0x00 5. " Mask demosaic rgbir bist sequencer error test timeout  , Demosaic rgbir: Mask of demosaic rgbir bist sequencer error test timeout.  "
bitfld.long 0x00 6. " Mask demosaic rgbir bist sequencer error test collision  , Demosaic rgbir: Mask of demosaic rgbir bist sequencer error test collision.  "
bitfld.long 0x00 7. " Mask demosaic rgbir config checker config error  , Demosaic rgbir: Mask of demosaic rgbir config checker config error.  "
textline "                 "
bitfld.long 0x00 8. " Mask frame check isp crop fault o  , Frame check isp crop: Mask of frame check isp crop fault o.  "
bitfld.long 0x00 9. " Mask out format crc vdata1 rgb o fault crc mismatch  , Out format: Mask of out format crc vdata1 rgb o fault crc mismatch.  "
bitfld.long 0x00 10. " Mask out format crc vdata2 rgb o fault crc mismatch  , Out format: Mask of out format crc vdata2 rgb o fault crc mismatch.  "
bitfld.long 0x00 11. " Mask out format crc vdata3 rgb o fault crc mismatch  , Out format: Mask of out format crc vdata3 rgb o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 12. " Mask out format crc vdata1 cm o fault crc mismatch  , Out format: Mask of out format crc vdata1 cm o fault crc mismatch.  "
bitfld.long 0x00 13. " Mask out format crc vdata2 cm o fault crc mismatch  , Out format: Mask of out format crc vdata2 cm o fault crc mismatch.  "
bitfld.long 0x00 14. " Mask out format crc vdata3 cm o fault crc mismatch  , Out format: Mask of out format crc vdata3 cm o fault crc mismatch.  "
bitfld.long 0x00 15. " Mask out format crc vdata1 ir o fault crc mismatch  , Out format: Mask of out format crc vdata1 ir o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 16. " Mask out format crc vdata1 yuv o fault crc mismatch  , Out format: Mask of out format crc vdata1 yuv o fault crc mismatch.  "
bitfld.long 0x00 17. " Mask out format crc vdata2 yuv o fault crc mismatch  , Out format: Mask of out format crc vdata2 yuv o fault crc mismatch.  "
bitfld.long 0x00 18. " Mask out format crc vdata3 yuv o fault crc mismatch  , Out format: Mask of out format crc vdata3 yuv o fault crc mismatch.  "
bitfld.long 0x00 19. " Mask out format crc vdata1 luv o fault crc mismatch  , Out format: Mask of out format crc vdata1 luv o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 20. " Mask out format crc vdata1 hs o fault crc mismatch  , Out format: Mask of out format crc vdata1 hs o fault crc mismatch.  "
bitfld.long 0x00 21. " Mask out format crc vdata2 hs o fault crc mismatch  , Out format: Mask of out format crc vdata2 hs o fault crc mismatch.  "
bitfld.long 0x00 22. " Mask out format crc vdata1 s o fault crc mismatch  , Out format: Mask of out format crc vdata1 s o fault crc mismatch.  "
bitfld.long 0x00 23. " Mask out format bist sequencer error test timeout  , Out format: Mask of out format bist sequencer error test timeout.  "
textline "                 "
bitfld.long 0x00 24. " Mask out format bist sequencer error test collision  , Out format: Mask of out format bist sequencer error test collision.  "
bitfld.long 0x00 25. " Mask out format config checker config error  , Out format: Mask of out format config checker config error.  "
bitfld.long 0x00 26. " Mask frame check isp out 2 fault o  , Frame check isp out 2: Mask of frame check isp out 2 fault o.  "
bitfld.long 0x00 27. " Mask frame check isp out 3 fault o  , Frame check isp out 3: Mask of frame check isp out 3 fault o.  "
textline "                 "
bitfld.long 0x00 28. " Mask frame check isp out 1 fault o  , Frame check isp out 1: Mask of frame check isp out 1 fault o.  "
bitfld.long 0x00 29. " Mask crc check 1 fault crc mismatch  , Crc check 1: Mask of crc check 1 fault crc mismatch.  "
bitfld.long 0x00 30. " Mask crc check 2 fault crc mismatch  , Crc check 2: Mask of crc check 2 fault crc mismatch.  "
bitfld.long 0x00 31. " Mask crc check 3 fault crc mismatch  , Crc check 3: Mask of crc check 3 fault crc mismatch.  "
group.long 0x102c++0x3
line.long 0x00 "0x102c"
textline "                 "
bitfld.long 0x00 0. " Mask crc check a1 fault crc mismatch  , Crc check a1: Mask of crc check a1 fault crc mismatch.  "
bitfld.long 0x00 1. " Mask crc check a2 fault crc mismatch  , Crc check a2: Mask of crc check a2 fault crc mismatch.  "
bitfld.long 0x00 2. " Mask crc check a3 fault crc mismatch  , Crc check a3: Mask of crc check a3 fault crc mismatch.  "
bitfld.long 0x00 3. " Mask pc fifo error serializer1 unsupported format  , Pc fifo: Mask of pc fifo error serializer1 unsupported format.  "
textline "                 "
bitfld.long 0x00 4. " Mask pc fifo error serializer1 output overflow  , Pc fifo: Mask of pc fifo error serializer1 output overflow.  "
bitfld.long 0x00 5. " Mask pc fifo error serializer2 unsupported format  , Pc fifo: Mask of pc fifo error serializer2 unsupported format.  "
bitfld.long 0x00 6. " Mask pc fifo error serializer2 output overflow  , Pc fifo: Mask of pc fifo error serializer2 output overflow.  "
bitfld.long 0x00 7. " Mask pc fifo error fifo in crc2 fifo crc mismatch  , Pc fifo: Mask of pc fifo error fifo in crc2 fifo crc mismatch.  "
textline "                 "
bitfld.long 0x00 8. " Mask pc fifo error fifo in crc2 crc fifo overflow  , Pc fifo: Mask of pc fifo error fifo in crc2 crc fifo overflow.  "
bitfld.long 0x00 9. " Mask pc fifo error synchronizer framing  , Pc fifo: Mask of pc fifo error synchronizer framing.  "
bitfld.long 0x00 10. " Mask pc fifo error combiner framing  , Pc fifo: Mask of pc fifo error combiner framing.  "
bitfld.long 0x00 11. " Mask pc fifo error combiner configuration  , Pc fifo: Mask of pc fifo error combiner configuration.  "
textline "                 "
bitfld.long 0x00 12. " Mask pc fifo error deserializer unsupported format  , Pc fifo: Mask of pc fifo error deserializer unsupported format.  "
bitfld.long 0x00 13. " Mask pc fifo error deserializer geometry  , Pc fifo: Mask of pc fifo error deserializer geometry.  "
bitfld.long 0x00 14. " Mask metering aexp config checker config error  , Metering aexp: Mask of metering aexp config checker config error.  "
bitfld.long 0x00 15. " Mask metering awb config checker config error  , Metering awb: Mask of metering awb config checker config error.  "
textline "                 "
bitfld.long 0x00 16. " Mask uroi config checker config error  , Uroi: Mask of uroi config checker config error.  "
hexmask.long.byte 0x00 17.--18. 1. " Mask metering arb error access out of range  ,Metering arb: Mask of metering arb error access out of range."
textline "                 "
bitfld.long 0x00 19. " Mask raw frontend delay line5 check delay line error  , Raw frontend delay line5 check: Mask of raw frontend delay line5 check delay line error.  "
bitfld.long 0x00 20. " Mask iridix delay line check delay line error  , Iridix delay line check: Mask of iridix delay line check delay line error.  "
bitfld.long 0x00 21. " Mask out format uv delay line check delay line error  , Out format uv delay line check: Mask of out format uv delay line check delay line error.  "
bitfld.long 0x00 22. " Mask out format ab delay line check delay line error  , Out format ab delay line check: Mask of out format ab delay line check delay line error.  "
textline "                 "
bitfld.long 0x00 23. " Mask sinter delay line check delay line error  , Sinter delay line check: Mask of sinter delay line check delay line error.  "
bitfld.long 0x00 24. " Mask interrupts error interrupt double  , Interrupts: Mask of interrupts error interrupt double.  "
hexmask.long.word 0x00 27.--31. 1. " Mask arb hist error access out of range  ,Arb hist: Mask of arb hist error access out of range."
group.long 0x1040++0x3
line.long 0x00 "0x1040"
textline "                 "
bitfld.long 0x00 0. " Status config pclk2 top fault s address range  , Config pclk2 top: Status of config pclk2 top fault s address range.  "
bitfld.long 0x00 1. " Status config pclk2 top fault h rvalid  , Config pclk2 top: Status of config pclk2 top fault h rvalid.  "
bitfld.long 0x00 2. " Status config pclk top fault s address range  , Config pclk top: Status of config pclk top fault s address range.  "
bitfld.long 0x00 3. " Status config pclk top fault h rvalid  , Config pclk top: Status of config pclk top fault h rvalid.  "
textline "                 "
bitfld.long 0x00 4. " Status config top apb fault s address range  , Config top apb: Status of config top apb fault s address range.  "
bitfld.long 0x00 5. " Status config top apb fault h rvalid  , Config top apb: Status of config top apb fault h rvalid.  "
bitfld.long 0x00 6. " Status error active width below limit  , Frame check sensor 1: Status of error active width below limit.  "
bitfld.long 0x00 7. " Status error active width above limit  , Frame check sensor 1: Status of error active width above limit.  "
textline "                 "
bitfld.long 0x00 8. " Status error active height below limit  , Frame check sensor 1: Status of error active height below limit.  "
bitfld.long 0x00 9. " Status error active height above limit  , Frame check sensor 1: Status of error active height above limit.  "
bitfld.long 0x00 10. " Status error horizontal blank below limit  , Frame check sensor 1: Status of error horizontal blank below limit.  "
bitfld.long 0x00 11. " Status error horizontal blank above limit  , Frame check sensor 1: Status of error horizontal blank above limit.  "
textline "                 "
bitfld.long 0x00 12. " Status error vertical blank below limit  , Frame check sensor 1: Status of error vertical blank below limit.  "
bitfld.long 0x00 13. " Status error vertical blank above limit  , Frame check sensor 1: Status of error vertical blank above limit.  "
bitfld.long 0x00 14. " Status error field during active video  , Frame check sensor 1: Status of error field during active video.  "
bitfld.long 0x00 15. " Status error extra field during vblanking  , Frame check sensor 1: Status of error extra field during vblanking.  "
textline "                 "
bitfld.long 0x00 16. " Status error manual trigger  , Frame check sensor 1: Status of error manual trigger.  "
bitfld.long 0x00 17. " Status error internal fault  , Frame check sensor 1: Status of error internal fault.  "
bitfld.long 0x00 18. " Status config vclk top fault s address range  , Config vclk top: Status of config vclk top fault s address range.  "
bitfld.long 0x00 19. " Status config vclk top fault h rvalid  , Config vclk top: Status of config vclk top fault h rvalid.  "
textline "                 "
bitfld.long 0x00 20. " Status config frontend top fault s address range  , Config frontend top: Status of config frontend top fault s address range.  "
bitfld.long 0x00 21. " Status config frontend top fault h rvalid  , Config frontend top: Status of config frontend top fault h rvalid.  "
bitfld.long 0x00 22. " Status config top cdma fault s address range  , Config top cdma: Status of config top cdma fault s address range.  "
bitfld.long 0x00 23. " Status config top cdma fault h rvalid  , Config top cdma: Status of config top cdma fault h rvalid.  "
textline "                 "
bitfld.long 0x00 24. " Status mcfe error serializer1 unsupported format  , Mcfe: Status of mcfe error serializer1 unsupported format.  "
bitfld.long 0x00 25. " Status mcfe error serializer1 output overflow  , Mcfe: Status of mcfe error serializer1 output overflow.  "
bitfld.long 0x00 26. " Status mcfe error fifo in crc1 fifo crc mismatch  , Mcfe: Status of mcfe error fifo in crc1 fifo crc mismatch.  "
bitfld.long 0x00 27. " Status mcfe error fifo in crc1 crc fifo overflow  , Mcfe: Status of mcfe error fifo in crc1 crc fifo overflow.  "
textline "                 "
bitfld.long 0x00 28. " Status mcfe error axi writer1 bresp  , Mcfe: Status of mcfe error axi writer1 bresp.  "
bitfld.long 0x00 29. " Status mcfe error axi writer1 awmaxwait  , Mcfe: Status of mcfe error axi writer1 awmaxwait.  "
bitfld.long 0x00 30. " Status mcfe error axi writer1 wmaxwait  , Mcfe: Status of mcfe error axi writer1 wmaxwait.  "
bitfld.long 0x00 31. " Status mcfe error axi writer1 wxact ostand  , Mcfe: Status of mcfe error axi writer1 wxact ostand.  "
group.long 0x1044++0x3
line.long 0x00 "0x1044"
textline "                 "
bitfld.long 0x00 0. " Status mcfe error axi writer1 user intfc  , Mcfe: Status of mcfe error axi writer1 user intfc.  "
bitfld.long 0x00 1. " Status mcfe error axi writer1 fifo fail full  , Mcfe: Status of mcfe error axi writer1 fifo fail full.  "
bitfld.long 0x00 2. " Status mcfe error axi writer1 fifo fail empty  , Mcfe: Status of mcfe error axi writer1 fifo fail empty.  "
bitfld.long 0x00 3. " Status mcfe error axi writer1 frame dropped  , Mcfe: Status of mcfe error axi writer1 frame dropped.  "
textline "                 "
bitfld.long 0x00 4. " Status mcfe error fb manager1 internal  , Mcfe: Status of mcfe error fb manager1 internal.  "
bitfld.long 0x00 5. " Status mcfe error serializer2 unsupported format  , Mcfe: Status of mcfe error serializer2 unsupported format.  "
bitfld.long 0x00 6. " Status mcfe error serializer2 output overflow  , Mcfe: Status of mcfe error serializer2 output overflow.  "
bitfld.long 0x00 7. " Status mcfe error fifo in crc2 fifo crc mismatch  , Mcfe: Status of mcfe error fifo in crc2 fifo crc mismatch.  "
textline "                 "
bitfld.long 0x00 8. " Status mcfe error fifo in crc2 crc fifo overflow  , Mcfe: Status of mcfe error fifo in crc2 crc fifo overflow.  "
bitfld.long 0x00 9. " Status mcfe error axi writer2 bresp  , Mcfe: Status of mcfe error axi writer2 bresp.  "
bitfld.long 0x00 10. " Status mcfe error axi writer2 awmaxwait  , Mcfe: Status of mcfe error axi writer2 awmaxwait.  "
bitfld.long 0x00 11. " Status mcfe error axi writer2 wmaxwait  , Mcfe: Status of mcfe error axi writer2 wmaxwait.  "
textline "                 "
bitfld.long 0x00 12. " Status mcfe error axi writer2 wxact ostand  , Mcfe: Status of mcfe error axi writer2 wxact ostand.  "
bitfld.long 0x00 13. " Status mcfe error axi writer2 user intfc  , Mcfe: Status of mcfe error axi writer2 user intfc.  "
bitfld.long 0x00 14. " Status mcfe error axi writer2 fifo fail full  , Mcfe: Status of mcfe error axi writer2 fifo fail full.  "
bitfld.long 0x00 15. " Status mcfe error axi writer2 fifo fail empty  , Mcfe: Status of mcfe error axi writer2 fifo fail empty.  "
textline "                 "
bitfld.long 0x00 16. " Status mcfe error axi writer2 frame dropped  , Mcfe: Status of mcfe error axi writer2 frame dropped.  "
bitfld.long 0x00 17. " Status mcfe error fb manager2 internal  , Mcfe: Status of mcfe error fb manager2 internal.  "
bitfld.long 0x00 18. " Status mcfe error serializer3 unsupported format  , Mcfe: Status of mcfe error serializer3 unsupported format.  "
bitfld.long 0x00 19. " Status mcfe error serializer3 output overflow  , Mcfe: Status of mcfe error serializer3 output overflow.  "
textline "                 "
bitfld.long 0x00 20. " Status mcfe error fifo in crc3 fifo crc mismatch  , Mcfe: Status of mcfe error fifo in crc3 fifo crc mismatch.  "
bitfld.long 0x00 21. " Status mcfe error fifo in crc3 crc fifo overflow  , Mcfe: Status of mcfe error fifo in crc3 crc fifo overflow.  "
bitfld.long 0x00 22. " Status mcfe error axi writer3 bresp  , Mcfe: Status of mcfe error axi writer3 bresp.  "
bitfld.long 0x00 23. " Status mcfe error axi writer3 awmaxwait  , Mcfe: Status of mcfe error axi writer3 awmaxwait.  "
textline "                 "
bitfld.long 0x00 24. " Status mcfe error axi writer3 wmaxwait  , Mcfe: Status of mcfe error axi writer3 wmaxwait.  "
bitfld.long 0x00 25. " Status mcfe error axi writer3 wxact ostand  , Mcfe: Status of mcfe error axi writer3 wxact ostand.  "
bitfld.long 0x00 26. " Status mcfe error axi writer3 user intfc  , Mcfe: Status of mcfe error axi writer3 user intfc.  "
bitfld.long 0x00 27. " Status mcfe error axi writer3 fifo fail full  , Mcfe: Status of mcfe error axi writer3 fifo fail full.  "
textline "                 "
bitfld.long 0x00 28. " Status mcfe error axi writer3 fifo fail empty  , Mcfe: Status of mcfe error axi writer3 fifo fail empty.  "
bitfld.long 0x00 29. " Status mcfe error axi writer3 frame dropped  , Mcfe: Status of mcfe error axi writer3 frame dropped.  "
bitfld.long 0x00 30. " Status mcfe error fb manager3 internal  , Mcfe: Status of mcfe error fb manager3 internal.  "
bitfld.long 0x00 31. " Status mcfe error serializer4 unsupported format  , Mcfe: Status of mcfe error serializer4 unsupported format.  "
group.long 0x1048++0x3
line.long 0x00 "0x1048"
textline "                 "
bitfld.long 0x00 0. " Status mcfe error serializer4 output overflow  , Mcfe: Status of mcfe error serializer4 output overflow.  "
bitfld.long 0x00 1. " Status mcfe error fifo in crc4 fifo crc mismatch  , Mcfe: Status of mcfe error fifo in crc4 fifo crc mismatch.  "
bitfld.long 0x00 2. " Status mcfe error fifo in crc4 crc fifo overflow  , Mcfe: Status of mcfe error fifo in crc4 crc fifo overflow.  "
bitfld.long 0x00 3. " Status mcfe error axi writer4 bresp  , Mcfe: Status of mcfe error axi writer4 bresp.  "
textline "                 "
bitfld.long 0x00 4. " Status mcfe error axi writer4 awmaxwait  , Mcfe: Status of mcfe error axi writer4 awmaxwait.  "
bitfld.long 0x00 5. " Status mcfe error axi writer4 wmaxwait  , Mcfe: Status of mcfe error axi writer4 wmaxwait.  "
bitfld.long 0x00 6. " Status mcfe error axi writer4 wxact ostand  , Mcfe: Status of mcfe error axi writer4 wxact ostand.  "
bitfld.long 0x00 7. " Status mcfe error axi writer4 user intfc  , Mcfe: Status of mcfe error axi writer4 user intfc.  "
textline "                 "
bitfld.long 0x00 8. " Status mcfe error axi writer4 fifo fail full  , Mcfe: Status of mcfe error axi writer4 fifo fail full.  "
bitfld.long 0x00 9. " Status mcfe error axi writer4 fifo fail empty  , Mcfe: Status of mcfe error axi writer4 fifo fail empty.  "
bitfld.long 0x00 10. " Status mcfe error axi writer4 frame dropped  , Mcfe: Status of mcfe error axi writer4 frame dropped.  "
bitfld.long 0x00 11. " Status mcfe error fb manager4 internal  , Mcfe: Status of mcfe error fb manager4 internal.  "
textline "                 "
bitfld.long 0x00 12. " Status mcfe error axi reader1 armaxwait  , Mcfe: Status of mcfe error axi reader1 armaxwait.  "
bitfld.long 0x00 13. " Status mcfe error axi reader1 rresp  , Mcfe: Status of mcfe error axi reader1 rresp.  "
bitfld.long 0x00 14. " Status mcfe error axi reader1 rxnfr ostand  , Mcfe: Status of mcfe error axi reader1 rxnfr ostand.  "
bitfld.long 0x00 15. " Status mcfe error axi reader1 user intfc  , Mcfe: Status of mcfe error axi reader1 user intfc.  "
textline "                 "
bitfld.long 0x00 16. " Status mcfe error axi reader1 fifo fail full  , Mcfe: Status of mcfe error axi reader1 fifo fail full.  "
bitfld.long 0x00 17. " Status mcfe error axi reader1 fifo fail empty  , Mcfe: Status of mcfe error axi reader1 fifo fail empty.  "
bitfld.long 0x00 18. " Status mcfe error fifo out crc1 fifo crc mismatch  , Mcfe: Status of mcfe error fifo out crc1 fifo crc mismatch.  "
bitfld.long 0x00 19. " Status mcfe error fifo out crc1 crc fifo overflow  , Mcfe: Status of mcfe error fifo out crc1 crc fifo overflow.  "
textline "                 "
bitfld.long 0x00 20. " Status mcfe error deserializer1 unsupported format  , Mcfe: Status of mcfe error deserializer1 unsupported format.  "
bitfld.long 0x00 21. " Status mcfe error deserializer1 geometry  , Mcfe: Status of mcfe error deserializer1 geometry.  "
bitfld.long 0x00 22. " Status mcfe error deserializer1 underrun  , Mcfe: Status of mcfe error deserializer1 underrun.  "
bitfld.long 0x00 23. " Status mcfe error axi reader2 armaxwait  , Mcfe: Status of mcfe error axi reader2 armaxwait.  "
textline "                 "
bitfld.long 0x00 24. " Status mcfe error axi reader2 rresp  , Mcfe: Status of mcfe error axi reader2 rresp.  "
bitfld.long 0x00 25. " Status mcfe error axi reader2 rxnfr ostand  , Mcfe: Status of mcfe error axi reader2 rxnfr ostand.  "
bitfld.long 0x00 26. " Status mcfe error axi reader2 user intfc  , Mcfe: Status of mcfe error axi reader2 user intfc.  "
bitfld.long 0x00 27. " Status mcfe error axi reader2 fifo fail full  , Mcfe: Status of mcfe error axi reader2 fifo fail full.  "
textline "                 "
bitfld.long 0x00 28. " Status mcfe error axi reader2 fifo fail empty  , Mcfe: Status of mcfe error axi reader2 fifo fail empty.  "
bitfld.long 0x00 29. " Status mcfe error fifo out crc2 fifo crc mismatch  , Mcfe: Status of mcfe error fifo out crc2 fifo crc mismatch.  "
bitfld.long 0x00 30. " Status mcfe error fifo out crc2 crc fifo overflow  , Mcfe: Status of mcfe error fifo out crc2 crc fifo overflow.  "
bitfld.long 0x00 31. " Status mcfe error deserializer2 unsupported format  , Mcfe: Status of mcfe error deserializer2 unsupported format.  "
group.long 0x104c++0x3
line.long 0x00 "0x104c"
textline "                 "
bitfld.long 0x00 0. " Status mcfe error deserializer2 geometry  , Mcfe: Status of mcfe error deserializer2 geometry.  "
bitfld.long 0x00 1. " Status mcfe error deserializer2 underrun  , Mcfe: Status of mcfe error deserializer2 underrun.  "
bitfld.long 0x00 2. " Status mcfe error axi reader3 armaxwait  , Mcfe: Status of mcfe error axi reader3 armaxwait.  "
bitfld.long 0x00 3. " Status mcfe error axi reader3 rresp  , Mcfe: Status of mcfe error axi reader3 rresp.  "
textline "                 "
bitfld.long 0x00 4. " Status mcfe error axi reader3 rxnfr ostand  , Mcfe: Status of mcfe error axi reader3 rxnfr ostand.  "
bitfld.long 0x00 5. " Status mcfe error axi reader3 user intfc  , Mcfe: Status of mcfe error axi reader3 user intfc.  "
bitfld.long 0x00 6. " Status mcfe error axi reader3 fifo fail full  , Mcfe: Status of mcfe error axi reader3 fifo fail full.  "
bitfld.long 0x00 7. " Status mcfe error axi reader3 fifo fail empty  , Mcfe: Status of mcfe error axi reader3 fifo fail empty.  "
textline "                 "
bitfld.long 0x00 8. " Status mcfe error fifo out crc3 fifo crc mismatch  , Mcfe: Status of mcfe error fifo out crc3 fifo crc mismatch.  "
bitfld.long 0x00 9. " Status mcfe error fifo out crc3 crc fifo overflow  , Mcfe: Status of mcfe error fifo out crc3 crc fifo overflow.  "
bitfld.long 0x00 10. " Status mcfe error deserializer3 unsupported format  , Mcfe: Status of mcfe error deserializer3 unsupported format.  "
bitfld.long 0x00 11. " Status mcfe error deserializer3 geometry  , Mcfe: Status of mcfe error deserializer3 geometry.  "
textline "                 "
bitfld.long 0x00 12. " Status mcfe error deserializer3 underrun  , Mcfe: Status of mcfe error deserializer3 underrun.  "
bitfld.long 0x00 13. " Status mcfe error axi reader4 armaxwait  , Mcfe: Status of mcfe error axi reader4 armaxwait.  "
bitfld.long 0x00 14. " Status mcfe error axi reader4 rresp  , Mcfe: Status of mcfe error axi reader4 rresp.  "
bitfld.long 0x00 15. " Status mcfe error axi reader4 rxnfr ostand  , Mcfe: Status of mcfe error axi reader4 rxnfr ostand.  "
textline "                 "
bitfld.long 0x00 16. " Status mcfe error axi reader4 user intfc  , Mcfe: Status of mcfe error axi reader4 user intfc.  "
bitfld.long 0x00 17. " Status mcfe error axi reader4 fifo fail full  , Mcfe: Status of mcfe error axi reader4 fifo fail full.  "
bitfld.long 0x00 18. " Status mcfe error axi reader4 fifo fail empty  , Mcfe: Status of mcfe error axi reader4 fifo fail empty.  "
bitfld.long 0x00 19. " Status mcfe error fifo out crc4 fifo crc mismatch  , Mcfe: Status of mcfe error fifo out crc4 fifo crc mismatch.  "
textline "                 "
bitfld.long 0x00 20. " Status mcfe error fifo out crc4 crc fifo overflow  , Mcfe: Status of mcfe error fifo out crc4 crc fifo overflow.  "
bitfld.long 0x00 21. " Status mcfe error deserializer4 unsupported format  , Mcfe: Status of mcfe error deserializer4 unsupported format.  "
bitfld.long 0x00 22. " Status mcfe error deserializer4 geometry  , Mcfe: Status of mcfe error deserializer4 geometry.  "
bitfld.long 0x00 23. " Status mcfe error deserializer4 underrun  , Mcfe: Status of mcfe error deserializer4 underrun.  "
textline "                 "
bitfld.long 0x00 24. " Status mcfe error synchronizer framing  , Mcfe: Status of mcfe error synchronizer framing.  "
bitfld.long 0x00 25. " Status mcfe error scheduler buffer collision  , Mcfe: Status of mcfe error scheduler buffer collision.  "
hexmask.long.byte 0x00 26.--29. 1. " Status mcfe error scheduler input statistics overrun  ,Mcfe: Status of mcfe error scheduler input statistics overrun."
textline "                 "
bitfld.long 0x00 30. " Status mcfe error scheduler config  , Mcfe: Status of mcfe error scheduler config.  "
bitfld.long 0x00 31. " Status mcfe error scheduler internal error  , Mcfe: Status of mcfe error scheduler internal error.  "
group.long 0x1050++0x3
line.long 0x00 "0x1050"
bitfld.long 0x00 0. " Status mcfe error scheduler input data width mismatch  , Mcfe: Status of mcfe error scheduler input data width mismatch.  "
bitfld.long 0x00 1. " Status mcfe error scheduler read geometry mismatch  , Mcfe: Status of mcfe error scheduler read geometry mismatch.  "
hexmask.long.byte 0x00 2.--7. 1. " Status mcfe error scoreboard access  ,Mcfe: Status of mcfe error scoreboard access."
hexmask.long.byte 0x00 8.--13. 1. " Status mcfe error scoreboard invalid command  ,Mcfe: Status of mcfe error scoreboard invalid command."
textline "                 "
bitfld.long 0x00 14. " Status mcfe error scoreboard buffer collision  , Mcfe: Status of mcfe error scoreboard buffer collision.  "
hexmask.long.word 0x00 15.--20. 1. " Status mcfe error scoreboard crc mismatch  ,Mcfe: Status of mcfe error scoreboard crc mismatch."
textline "                 "
bitfld.long 0x00 21. " Status mcfe error buffer config buffer access  , Mcfe: Status of mcfe error buffer config buffer access.  "
bitfld.long 0x00 22. " Status mcfe error buffer config internal fault  , Mcfe: Status of mcfe error buffer config internal fault.  "
bitfld.long 0x00 23. " Status mcfe error buffer config config crc mismatch  , Mcfe: Status of mcfe error buffer config config crc mismatch.  "
bitfld.long 0x00 24. " Status mcfe error config dma armaxwait  , Mcfe: Status of mcfe error config dma armaxwait.  "
textline "                 "
bitfld.long 0x00 25. " Status mcfe error config dma rresp  , Mcfe: Status of mcfe error config dma rresp.  "
bitfld.long 0x00 26. " Status mcfe error config dma rxnfr ostand  , Mcfe: Status of mcfe error config dma rxnfr ostand.  "
bitfld.long 0x00 27. " Status mcfe error config dma user intfc  , Mcfe: Status of mcfe error config dma user intfc.  "
bitfld.long 0x00 28. " Status mcfe error config dma rfifo fail full  , Mcfe: Status of mcfe error config dma rfifo fail full.  "
textline "                 "
bitfld.long 0x00 29. " Status mcfe error config dma rfifo fail empty  , Mcfe: Status of mcfe error config dma rfifo fail empty.  "
bitfld.long 0x00 30. " Status mcfe error config dma bresp  , Mcfe: Status of mcfe error config dma bresp.  "
bitfld.long 0x00 31. " Status mcfe error config dma awmaxwait  , Mcfe: Status of mcfe error config dma awmaxwait.  "
group.long 0x1054++0x3
line.long 0x00 "0x1054"
bitfld.long 0x00 0. " Status mcfe error config dma wmaxwait  , Mcfe: Status of mcfe error config dma wmaxwait.  "
textline "                 "
bitfld.long 0x00 1. " Status mcfe error config dma wxact ostand  , Mcfe: Status of mcfe error config dma wxact ostand.  "
bitfld.long 0x00 2. " Status mcfe error config dma wfifo fail full  , Mcfe: Status of mcfe error config dma wfifo fail full.  "
bitfld.long 0x00 3. " Status mcfe error config dma wfifo fail empty  , Mcfe: Status of mcfe error config dma wfifo fail empty.  "
bitfld.long 0x00 4. " Status mcfe error config dma read overflow  , Mcfe: Status of mcfe error config dma read overflow.  "
textline "                 "
bitfld.long 0x00 5. " Status mcfe error config dma axi overread  , Mcfe: Status of mcfe error config dma axi overread.  "
bitfld.long 0x00 6. " Status mcfe error config dma axi overwrite  , Mcfe: Status of mcfe error config dma axi overwrite.  "
bitfld.long 0x00 7. " Status mcfe error config dma internal  , Mcfe: Status of mcfe error config dma internal.  "
bitfld.long 0x00 8. " Status mcbe error serializer1 unsupported format  , Mcbe: Status of mcbe error serializer1 unsupported format.  "
textline "                 "
bitfld.long 0x00 9. " Status mcbe error serializer1 output overflow  , Mcbe: Status of mcbe error serializer1 output overflow.  "
bitfld.long 0x00 10. " Status mcbe error fifo in crc1 fifo crc mismatch  , Mcbe: Status of mcbe error fifo in crc1 fifo crc mismatch.  "
bitfld.long 0x00 11. " Status mcbe error fifo in crc1 crc fifo overflow  , Mcbe: Status of mcbe error fifo in crc1 crc fifo overflow.  "
bitfld.long 0x00 12. " Status mcbe error axi writer1 bresp  , Mcbe: Status of mcbe error axi writer1 bresp.  "
textline "                 "
bitfld.long 0x00 13. " Status mcbe error axi writer1 awmaxwait  , Mcbe: Status of mcbe error axi writer1 awmaxwait.  "
bitfld.long 0x00 14. " Status mcbe error axi writer1 wmaxwait  , Mcbe: Status of mcbe error axi writer1 wmaxwait.  "
bitfld.long 0x00 15. " Status mcbe error axi writer1 wxact ostand  , Mcbe: Status of mcbe error axi writer1 wxact ostand.  "
bitfld.long 0x00 16. " Status mcbe error axi writer1 user intfc  , Mcbe: Status of mcbe error axi writer1 user intfc.  "
textline "                 "
bitfld.long 0x00 17. " Status mcbe error axi writer1 fifo fail full  , Mcbe: Status of mcbe error axi writer1 fifo fail full.  "
bitfld.long 0x00 18. " Status mcbe error axi writer1 fifo fail empty  , Mcbe: Status of mcbe error axi writer1 fifo fail empty.  "
bitfld.long 0x00 19. " Status mcbe error axi writer1 frame dropped  , Mcbe: Status of mcbe error axi writer1 frame dropped.  "
bitfld.long 0x00 20. " Status mcbe error fb manager1 internal  , Mcbe: Status of mcbe error fb manager1 internal.  "
textline "                 "
bitfld.long 0x00 21. " Status mcbe error serializer2 unsupported format  , Mcbe: Status of mcbe error serializer2 unsupported format.  "
bitfld.long 0x00 22. " Status mcbe error serializer2 output overflow  , Mcbe: Status of mcbe error serializer2 output overflow.  "
bitfld.long 0x00 23. " Status mcbe error fifo in crc2 fifo crc mismatch  , Mcbe: Status of mcbe error fifo in crc2 fifo crc mismatch.  "
bitfld.long 0x00 24. " Status mcbe error fifo in crc2 crc fifo overflow  , Mcbe: Status of mcbe error fifo in crc2 crc fifo overflow.  "
textline "                 "
bitfld.long 0x00 25. " Status mcbe error axi writer2 bresp  , Mcbe: Status of mcbe error axi writer2 bresp.  "
bitfld.long 0x00 26. " Status mcbe error axi writer2 awmaxwait  , Mcbe: Status of mcbe error axi writer2 awmaxwait.  "
bitfld.long 0x00 27. " Status mcbe error axi writer2 wmaxwait  , Mcbe: Status of mcbe error axi writer2 wmaxwait.  "
bitfld.long 0x00 28. " Status mcbe error axi writer2 wxact ostand  , Mcbe: Status of mcbe error axi writer2 wxact ostand.  "
textline "                 "
bitfld.long 0x00 29. " Status mcbe error axi writer2 user intfc  , Mcbe: Status of mcbe error axi writer2 user intfc.  "
bitfld.long 0x00 30. " Status mcbe error axi writer2 fifo fail full  , Mcbe: Status of mcbe error axi writer2 fifo fail full.  "
bitfld.long 0x00 31. " Status mcbe error axi writer2 fifo fail empty  , Mcbe: Status of mcbe error axi writer2 fifo fail empty.  "
group.long 0x1058++0x3
line.long 0x00 "0x1058"
bitfld.long 0x00 0. " Status mcbe error axi writer2 frame dropped  , Mcbe: Status of mcbe error axi writer2 frame dropped.  "
textline "                 "
bitfld.long 0x00 1. " Status mcbe error fb manager2 internal  , Mcbe: Status of mcbe error fb manager2 internal.  "
bitfld.long 0x00 2. " Status mcbe error serializer3 unsupported format  , Mcbe: Status of mcbe error serializer3 unsupported format.  "
bitfld.long 0x00 3. " Status mcbe error serializer3 output overflow  , Mcbe: Status of mcbe error serializer3 output overflow.  "
bitfld.long 0x00 4. " Status mcbe error fifo in crc3 fifo crc mismatch  , Mcbe: Status of mcbe error fifo in crc3 fifo crc mismatch.  "
textline "                 "
bitfld.long 0x00 5. " Status mcbe error fifo in crc3 crc fifo overflow  , Mcbe: Status of mcbe error fifo in crc3 crc fifo overflow.  "
bitfld.long 0x00 6. " Status mcbe error axi writer3 bresp  , Mcbe: Status of mcbe error axi writer3 bresp.  "
bitfld.long 0x00 7. " Status mcbe error axi writer3 awmaxwait  , Mcbe: Status of mcbe error axi writer3 awmaxwait.  "
bitfld.long 0x00 8. " Status mcbe error axi writer3 wmaxwait  , Mcbe: Status of mcbe error axi writer3 wmaxwait.  "
textline "                 "
bitfld.long 0x00 9. " Status mcbe error axi writer3 wxact ostand  , Mcbe: Status of mcbe error axi writer3 wxact ostand.  "
bitfld.long 0x00 10. " Status mcbe error axi writer3 user intfc  , Mcbe: Status of mcbe error axi writer3 user intfc.  "
bitfld.long 0x00 11. " Status mcbe error axi writer3 fifo fail full  , Mcbe: Status of mcbe error axi writer3 fifo fail full.  "
bitfld.long 0x00 12. " Status mcbe error axi writer3 fifo fail empty  , Mcbe: Status of mcbe error axi writer3 fifo fail empty.  "
textline "                 "
bitfld.long 0x00 13. " Status mcbe error axi writer3 frame dropped  , Mcbe: Status of mcbe error axi writer3 frame dropped.  "
bitfld.long 0x00 14. " Status mcbe error fb manager3 internal  , Mcbe: Status of mcbe error fb manager3 internal.  "
bitfld.long 0x00 15. " Status mcbe error serializer4 unsupported format  , Mcbe: Status of mcbe error serializer4 unsupported format.  "
bitfld.long 0x00 16. " Status mcbe error serializer4 output overflow  , Mcbe: Status of mcbe error serializer4 output overflow.  "
textline "                 "
bitfld.long 0x00 17. " Status mcbe error fifo in crc4 fifo crc mismatch  , Mcbe: Status of mcbe error fifo in crc4 fifo crc mismatch.  "
bitfld.long 0x00 18. " Status mcbe error fifo in crc4 crc fifo overflow  , Mcbe: Status of mcbe error fifo in crc4 crc fifo overflow.  "
bitfld.long 0x00 19. " Status mcbe error axi writer4 bresp  , Mcbe: Status of mcbe error axi writer4 bresp.  "
bitfld.long 0x00 20. " Status mcbe error axi writer4 awmaxwait  , Mcbe: Status of mcbe error axi writer4 awmaxwait.  "
textline "                 "
bitfld.long 0x00 21. " Status mcbe error axi writer4 wmaxwait  , Mcbe: Status of mcbe error axi writer4 wmaxwait.  "
bitfld.long 0x00 22. " Status mcbe error axi writer4 wxact ostand  , Mcbe: Status of mcbe error axi writer4 wxact ostand.  "
bitfld.long 0x00 23. " Status mcbe error axi writer4 user intfc  , Mcbe: Status of mcbe error axi writer4 user intfc.  "
bitfld.long 0x00 24. " Status mcbe error axi writer4 fifo fail full  , Mcbe: Status of mcbe error axi writer4 fifo fail full.  "
textline "                 "
bitfld.long 0x00 25. " Status mcbe error axi writer4 fifo fail empty  , Mcbe: Status of mcbe error axi writer4 fifo fail empty.  "
bitfld.long 0x00 26. " Status mcbe error axi writer4 frame dropped  , Mcbe: Status of mcbe error axi writer4 frame dropped.  "
bitfld.long 0x00 27. " Status mcbe error fb manager4 internal  , Mcbe: Status of mcbe error fb manager4 internal.  "
hexmask.long.word 0x00 28.--31. 1. " Status mcbe error scoreboard access  ,Mcbe: Status of mcbe error scoreboard access."
group.long 0x105c++0x3
line.long 0x00 "0x105c"
hexmask.long.byte 0x00 1.--5. 1. " Status mcbe error scoreboard invalid command  ,Mcbe: Status of mcbe error scoreboard invalid command."
textline "                 "
bitfld.long 0x00 6. " Status mcbe error scoreboard buffer collision  , Mcbe: Status of mcbe error scoreboard buffer collision.  "
hexmask.long.word 0x00 7.--11. 1. " Status mcbe error scoreboard crc mismatch  ,Mcbe: Status of mcbe error scoreboard crc mismatch."
textline "                 "
bitfld.long 0x00 12. " Status mcbe error buffer config buffer access  , Mcbe: Status of mcbe error buffer config buffer access.  "
bitfld.long 0x00 13. " Status mcbe error buffer config internal fault  , Mcbe: Status of mcbe error buffer config internal fault.  "
bitfld.long 0x00 14. " Status mcbe error buffer config config crc mismatch  , Mcbe: Status of mcbe error buffer config config crc mismatch.  "
bitfld.long 0x00 15. " Status stream crossbar error invalid configuration  , Stream crossbar: Status of stream crossbar error invalid configuration.  "
textline "                 "
bitfld.long 0x00 16. " Status frame check sensor 1 fault o  , Frame check sensor 1: Status of frame check sensor 1 fault o.  "
bitfld.long 0x00 17. " Status frame repeat sensor 1 repeating frame warning  , Frame repeat sensor 1: Status of frame repeat sensor 1 repeating frame warning.  "
bitfld.long 0x00 18. " Status frame repeat sensor 1 repeating frame error  , Frame repeat sensor 1: Status of frame repeat sensor 1 repeating frame error.  "
bitfld.long 0x00 19. " Status metering hist 1 config checker config error  , Metering hist 1: Status of metering hist 1 config checker config error.  "
textline "                 "
bitfld.long 0x00 20. " Status frame check sensor 2 fault o  , Frame check sensor 2: Status of frame check sensor 2 fault o.  "
bitfld.long 0x00 21. " Status frame repeat sensor 2 repeating frame warning  , Frame repeat sensor 2: Status of frame repeat sensor 2 repeating frame warning.  "
bitfld.long 0x00 22. " Status frame repeat sensor 2 repeating frame error  , Frame repeat sensor 2: Status of frame repeat sensor 2 repeating frame error.  "
bitfld.long 0x00 23. " Status metering hist 2 config checker config error  , Metering hist 2: Status of metering hist 2 config checker config error.  "
textline "                 "
bitfld.long 0x00 24. " Status frame check sensor 3 fault o  , Frame check sensor 3: Status of frame check sensor 3 fault o.  "
bitfld.long 0x00 25. " Status frame repeat sensor 3 repeating frame warning  , Frame repeat sensor 3: Status of frame repeat sensor 3 repeating frame warning.  "
bitfld.long 0x00 26. " Status frame repeat sensor 3 repeating frame error  , Frame repeat sensor 3: Status of frame repeat sensor 3 repeating frame error.  "
bitfld.long 0x00 27. " Status metering hist 3 config checker config error  , Metering hist 3: Status of metering hist 3 config checker config error.  "
textline "                 "
bitfld.long 0x00 28. " Status frame check sensor 4 fault o  , Frame check sensor 4: Status of frame check sensor 4 fault o.  "
bitfld.long 0x00 29. " Status frame repeat sensor 4 repeating frame warning  , Frame repeat sensor 4: Status of frame repeat sensor 4 repeating frame warning.  "
bitfld.long 0x00 30. " Status frame repeat sensor 4 repeating frame error  , Frame repeat sensor 4: Status of frame repeat sensor 4 repeating frame error.  "
bitfld.long 0x00 31. " Status metering hist 4 config checker config error  , Metering hist 4: Status of metering hist 4 config checker config error.  "
group.long 0x1060++0x3
line.long 0x00 "0x1060"
textline "                 "
bitfld.long 0x00 0. " Status frame check isp fault o  , Frame check isp: Status of frame check isp fault o.  "
bitfld.long 0x00 1. " Status input formatter parameter error  , Input formatter: Status of input formatter parameter error.  "
bitfld.long 0x00 2. " Status frame stitch crc data o fault crc mismatch  , Frame stitch: Status of frame stitch crc data o fault crc mismatch.  "
bitfld.long 0x00 3. " Status frame stitch bist sequencer error test timeout  , Frame stitch: Status of frame stitch bist sequencer error test timeout.  "
textline "                 "
bitfld.long 0x00 4. " Status frame stitch bist sequencer error test collision  , Frame stitch: Status of frame stitch bist sequencer error test collision.  "
bitfld.long 0x00 5. " Status frame stitch config checker config error  , Frame stitch: Status of frame stitch config checker config error.  "
bitfld.long 0x00 6. " Status fstitch1 delay line check delay line error  , Fstitch1 delay line check: Status of fstitch1 delay line check delay line error.  "
bitfld.long 0x00 7. " Status fstitch2 delay line check delay line error  , Fstitch2 delay line check: Status of fstitch2 delay line check delay line error.  "
textline "                 "
bitfld.long 0x00 8. " Status fstitch3 delay line check delay line error  , Fstitch3 delay line check: Status of fstitch3 delay line check delay line error.  "
bitfld.long 0x00 9. " Status frame repeat isp repeating frame warning  , Frame repeat isp: Status of frame repeat isp repeating frame warning.  "
bitfld.long 0x00 10. " Status frame repeat isp repeating frame error  , Frame repeat isp: Status of frame repeat isp repeating frame error.  "
bitfld.long 0x00 11. " Status gamma fedl crc data o fault crc mismatch  , Gamma fedl: Status of gamma fedl crc data o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 12. " Status gamma fedl bist sequencer error test timeout  , Gamma fedl: Status of gamma fedl bist sequencer error test timeout.  "
bitfld.long 0x00 13. " Status gamma fedl bist sequencer error test collision  , Gamma fedl: Status of gamma fedl bist sequencer error test collision.  "
bitfld.long 0x00 14. " Status gamma fedl config checker config error  , Gamma fedl: Status of gamma fedl config checker config error.  "
bitfld.long 0x00 15. " Status roi hist 1 config checker config error  , Roi hist 1: Status of roi hist 1 config checker config error.  "
textline "                 "
bitfld.long 0x00 16. " Status roi hist 2 config checker config error  , Roi hist 2: Status of roi hist 2 config checker config error.  "
bitfld.long 0x00 17. " Status roi hist 3 config checker config error  , Roi hist 3: Status of roi hist 3 config checker config error.  "
bitfld.long 0x00 18. " Status roi hist 4 config checker config error  , Roi hist 4: Status of roi hist 4 config checker config error.  "
bitfld.long 0x00 19. " Status raw frontend crc data o fault crc mismatch  , Raw frontend: Status of raw frontend crc data o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 20. " Status raw frontend crc hp median fault crc mismatch  , Raw frontend: Status of raw frontend crc hp median fault crc mismatch.  "
bitfld.long 0x00 21. " Status raw frontend crc hotpixel marker fault crc mismatch  , Raw frontend: Status of raw frontend crc hotpixel marker fault crc mismatch.  "
bitfld.long 0x00 22. " Status raw frontend bist sequencer error test timeout  , Raw frontend: Status of raw frontend bist sequencer error test timeout.  "
bitfld.long 0x00 23. " Status raw frontend bist sequencer error test collision  , Raw frontend: Status of raw frontend bist sequencer error test collision.  "
textline "                 "
bitfld.long 0x00 24. " Status raw frontend config checker config error  , Raw frontend: Status of raw frontend config checker config error.  "
bitfld.long 0x00 25. " Status defect pixel config checker config error  , Defect pixel: Status of defect pixel config checker config error.  "
bitfld.long 0x00 26. " Status sinter crc vdata o fault crc mismatch  , Sinter: Status of sinter crc vdata o fault crc mismatch.  "
bitfld.long 0x00 27. " Status sinter bist sequencer error test timeout  , Sinter: Status of sinter bist sequencer error test timeout.  "
textline "                 "
bitfld.long 0x00 28. " Status sinter bist sequencer error test collision  , Sinter: Status of sinter bist sequencer error test collision.  "
bitfld.long 0x00 29. " Status sinter config checker config error  , Sinter: Status of sinter config checker config error.  "
bitfld.long 0x00 30. " Status ca correction delay line checker delay line error  , Ca correction delay line checker: Status of ca correction delay line checker delay line error.  "
bitfld.long 0x00 31. " Status ca correction error range  , Ca correction: Status of ca correction error range.  "
group.long 0x1064++0x3
line.long 0x00 "0x1064"
textline "                 "
bitfld.long 0x00 0. " Status ca correction error cache  , Ca correction: Status of ca correction error cache.  "
bitfld.long 0x00 1. " Status ca correction error address  , Ca correction: Status of ca correction error address.  "
bitfld.long 0x00 2. " Status ca correction config checker config error  , Ca correction: Status of ca correction config checker config error.  "
bitfld.long 0x00 3. " Status gamma bedl crc data o fault crc mismatch  , Gamma bedl: Status of gamma bedl crc data o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 4. " Status gamma bedl bist sequencer error test timeout  , Gamma bedl: Status of gamma bedl bist sequencer error test timeout.  "
bitfld.long 0x00 5. " Status gamma bedl bist sequencer error test collision  , Gamma bedl: Status of gamma bedl bist sequencer error test collision.  "
bitfld.long 0x00 6. " Status gamma bedl config checker config error  , Gamma bedl: Status of gamma bedl config checker config error.  "
bitfld.long 0x00 7. " Status radial shading crc data o fault crc mismatch  , Radial shading: Status of radial shading crc data o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 8. " Status radial shading bist sequencer error test timeout  , Radial shading: Status of radial shading bist sequencer error test timeout.  "
bitfld.long 0x00 9. " Status radial shading bist sequencer error test collision  , Radial shading: Status of radial shading bist sequencer error test collision.  "
bitfld.long 0x00 10. " Status radial shading config checker config error  , Radial shading: Status of radial shading config checker config error.  "
bitfld.long 0x00 11. " Status mesh shading config checker config error  , Mesh shading: Status of mesh shading config checker config error.  "
textline "                 "
bitfld.long 0x00 12. " Status iridix crc data o fault crc mismatch  , Iridix: Status of iridix crc data o fault crc mismatch.  "
bitfld.long 0x00 13. " Status iridix bist sequencer error test timeout  , Iridix: Status of iridix bist sequencer error test timeout.  "
bitfld.long 0x00 14. " Status iridix bist sequencer error test collision  , Iridix: Status of iridix bist sequencer error test collision.  "
bitfld.long 0x00 15. " Status iridix config checker config error  , Iridix: Status of iridix config checker config error.  "
textline "                 "
bitfld.long 0x00 16. " Status antifog hist config checker config error  , Antifog hist: Status of antifog hist config checker config error.  "
bitfld.long 0x00 17. " Status demosaic delay line checker delay line error  , Demosaic delay line checker: Status of demosaic delay line checker delay line error.  "
bitfld.long 0x00 18. " Status demosaic rccc crc vdata1 rc r o fault crc mismatch  , Demosaic rccc: Status of demosaic rccc crc vdata1 rc r o fault crc mismatch.  "
bitfld.long 0x00 19. " Status demosaic rccc crc vdata2 rc c o fault crc mismatch  , Demosaic rccc: Status of demosaic rccc crc vdata2 rc c o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 20. " Status demosaic rccc bist sequencer error test timeout  , Demosaic rccc: Status of demosaic rccc bist sequencer error test timeout.  "
bitfld.long 0x00 21. " Status demosaic rccc bist sequencer error test collision  , Demosaic rccc: Status of demosaic rccc bist sequencer error test collision.  "
bitfld.long 0x00 22. " Status demosaic rccc config checker config error  , Demosaic rccc: Status of demosaic rccc config checker config error.  "
bitfld.long 0x00 23. " Status demosaic crc red o fault crc mismatch  , Demosaic: Status of demosaic crc red o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 24. " Status demosaic crc grn o fault crc mismatch  , Demosaic: Status of demosaic crc grn o fault crc mismatch.  "
bitfld.long 0x00 25. " Status demosaic crc blu o fault crc mismatch  , Demosaic: Status of demosaic crc blu o fault crc mismatch.  "
bitfld.long 0x00 26. " Status demosaic crc mask sad o fault crc mismatch  , Demosaic: Status of demosaic crc mask sad o fault crc mismatch.  "
bitfld.long 0x00 27. " Status demosaic bist sequencer error test timeout  , Demosaic: Status of demosaic bist sequencer error test timeout.  "
textline "                 "
bitfld.long 0x00 28. " Status demosaic bist sequencer error test collision  , Demosaic: Status of demosaic bist sequencer error test collision.  "
bitfld.long 0x00 29. " Status demosaic config checker config error  , Demosaic: Status of demosaic config checker config error.  "
bitfld.long 0x00 30. " Status demosaic rgbir cfg calc fault o  , Demosaic rgbir: Status of demosaic rgbir cfg calc fault o.  "
bitfld.long 0x00 31. " Status demosaic rgbir demosaic rgbir cfg calc fault o  , Demosaic rgbir: Status of demosaic rgbir demosaic rgbir cfg calc fault o.  "
group.long 0x1068++0x3
line.long 0x00 "0x1068"
textline "                 "
bitfld.long 0x00 0. " Status demosaic rgbir crc rplane o fault crc mismatch  , Demosaic rgbir: Status of demosaic rgbir crc rplane o fault crc mismatch.  "
bitfld.long 0x00 1. " Status demosaic rgbir crc gplane o fault crc mismatch  , Demosaic rgbir: Status of demosaic rgbir crc gplane o fault crc mismatch.  "
bitfld.long 0x00 2. " Status demosaic rgbir crc bplane o fault crc mismatch  , Demosaic rgbir: Status of demosaic rgbir crc bplane o fault crc mismatch.  "
bitfld.long 0x00 3. " Status demosaic rgbir crc iplane o fault crc mismatch  , Demosaic rgbir: Status of demosaic rgbir crc iplane o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 4. " Status demosaic rgbir crc declip data o fault crc mismatch  , Demosaic rgbir: Status of demosaic rgbir crc declip data o fault crc mismatch.  "
bitfld.long 0x00 5. " Status demosaic rgbir bist sequencer error test timeout  , Demosaic rgbir: Status of demosaic rgbir bist sequencer error test timeout.  "
bitfld.long 0x00 6. " Status demosaic rgbir bist sequencer error test collision  , Demosaic rgbir: Status of demosaic rgbir bist sequencer error test collision.  "
bitfld.long 0x00 7. " Status demosaic rgbir config checker config error  , Demosaic rgbir: Status of demosaic rgbir config checker config error.  "
textline "                 "
bitfld.long 0x00 8. " Status frame check isp crop fault o  , Frame check isp crop: Status of frame check isp crop fault o.  "
bitfld.long 0x00 9. " Status out format crc vdata1 rgb o fault crc mismatch  , Out format: Status of out format crc vdata1 rgb o fault crc mismatch.  "
bitfld.long 0x00 10. " Status out format crc vdata2 rgb o fault crc mismatch  , Out format: Status of out format crc vdata2 rgb o fault crc mismatch.  "
bitfld.long 0x00 11. " Status out format crc vdata3 rgb o fault crc mismatch  , Out format: Status of out format crc vdata3 rgb o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 12. " Status out format crc vdata1 cm o fault crc mismatch  , Out format: Status of out format crc vdata1 cm o fault crc mismatch.  "
bitfld.long 0x00 13. " Status out format crc vdata2 cm o fault crc mismatch  , Out format: Status of out format crc vdata2 cm o fault crc mismatch.  "
bitfld.long 0x00 14. " Status out format crc vdata3 cm o fault crc mismatch  , Out format: Status of out format crc vdata3 cm o fault crc mismatch.  "
bitfld.long 0x00 15. " Status out format crc vdata1 ir o fault crc mismatch  , Out format: Status of out format crc vdata1 ir o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 16. " Status out format crc vdata1 yuv o fault crc mismatch  , Out format: Status of out format crc vdata1 yuv o fault crc mismatch.  "
bitfld.long 0x00 17. " Status out format crc vdata2 yuv o fault crc mismatch  , Out format: Status of out format crc vdata2 yuv o fault crc mismatch.  "
bitfld.long 0x00 18. " Status out format crc vdata3 yuv o fault crc mismatch  , Out format: Status of out format crc vdata3 yuv o fault crc mismatch.  "
bitfld.long 0x00 19. " Status out format crc vdata1 luv o fault crc mismatch  , Out format: Status of out format crc vdata1 luv o fault crc mismatch.  "
textline "                 "
bitfld.long 0x00 20. " Status out format crc vdata1 hs o fault crc mismatch  , Out format: Status of out format crc vdata1 hs o fault crc mismatch.  "
bitfld.long 0x00 21. " Status out format crc vdata2 hs o fault crc mismatch  , Out format: Status of out format crc vdata2 hs o fault crc mismatch.  "
bitfld.long 0x00 22. " Status out format crc vdata1 s o fault crc mismatch  , Out format: Status of out format crc vdata1 s o fault crc mismatch.  "
bitfld.long 0x00 23. " Status out format bist sequencer error test timeout  , Out format: Status of out format bist sequencer error test timeout.  "
textline "                 "
bitfld.long 0x00 24. " Status out format bist sequencer error test collision  , Out format: Status of out format bist sequencer error test collision.  "
bitfld.long 0x00 25. " Status out format config checker config error  , Out format: Status of out format config checker config error.  "
bitfld.long 0x00 26. " Status frame check isp out 2 fault o  , Frame check isp out 2: Status of frame check isp out 2 fault o.  "
bitfld.long 0x00 27. " Status frame check isp out 3 fault o  , Frame check isp out 3: Status of frame check isp out 3 fault o.  "
textline "                 "
bitfld.long 0x00 28. " Status frame check isp out 1 fault o  , Frame check isp out 1: Status of frame check isp out 1 fault o.  "
bitfld.long 0x00 29. " Status crc check 1 fault crc mismatch  , Crc check 1: Status of crc check 1 fault crc mismatch.  "
bitfld.long 0x00 30. " Status crc check 2 fault crc mismatch  , Crc check 2: Status of crc check 2 fault crc mismatch.  "
bitfld.long 0x00 31. " Status crc check 3 fault crc mismatch  , Crc check 3: Status of crc check 3 fault crc mismatch.  "
group.long 0x106c++0x3
line.long 0x00 "0x106c"
textline "                 "
bitfld.long 0x00 0. " Status crc check a1 fault crc mismatch  , Crc check a1: Status of crc check a1 fault crc mismatch.  "
bitfld.long 0x00 1. " Status crc check a2 fault crc mismatch  , Crc check a2: Status of crc check a2 fault crc mismatch.  "
bitfld.long 0x00 2. " Status crc check a3 fault crc mismatch  , Crc check a3: Status of crc check a3 fault crc mismatch.  "
bitfld.long 0x00 3. " Status pc fifo error serializer1 unsupported format  , Pc fifo: Status of pc fifo error serializer1 unsupported format.  "
textline "                 "
bitfld.long 0x00 4. " Status pc fifo error serializer1 output overflow  , Pc fifo: Status of pc fifo error serializer1 output overflow.  "
bitfld.long 0x00 5. " Status pc fifo error serializer2 unsupported format  , Pc fifo: Status of pc fifo error serializer2 unsupported format.  "
bitfld.long 0x00 6. " Status pc fifo error serializer2 output overflow  , Pc fifo: Status of pc fifo error serializer2 output overflow.  "
bitfld.long 0x00 7. " Status pc fifo error fifo in crc2 fifo crc mismatch  , Pc fifo: Status of pc fifo error fifo in crc2 fifo crc mismatch.  "
textline "                 "
bitfld.long 0x00 8. " Status pc fifo error fifo in crc2 crc fifo overflow  , Pc fifo: Status of pc fifo error fifo in crc2 crc fifo overflow.  "
bitfld.long 0x00 9. " Status pc fifo error synchronizer framing  , Pc fifo: Status of pc fifo error synchronizer framing.  "
bitfld.long 0x00 10. " Status pc fifo error combiner framing  , Pc fifo: Status of pc fifo error combiner framing.  "
bitfld.long 0x00 11. " Status pc fifo error combiner configuration  , Pc fifo: Status of pc fifo error combiner configuration.  "
textline "                 "
bitfld.long 0x00 12. " Status pc fifo error deserializer unsupported format  , Pc fifo: Status of pc fifo error deserializer unsupported format.  "
bitfld.long 0x00 13. " Status pc fifo error deserializer geometry  , Pc fifo: Status of pc fifo error deserializer geometry.  "
bitfld.long 0x00 14. " Status metering aexp config checker config error  , Metering aexp: Status of metering aexp config checker config error.  "
bitfld.long 0x00 15. " Status metering awb config checker config error  , Metering awb: Status of metering awb config checker config error.  "
textline "                 "
bitfld.long 0x00 16. " Status uroi config checker config error  , Uroi: Status of uroi config checker config error.  "
hexmask.long.byte 0x00 17.--18. 1. " Status metering arb error access out of range  ,Metering arb: Status of metering arb error access out of range."
textline "                 "
bitfld.long 0x00 19. " Status raw frontend delay line5 check delay line error  , Raw frontend delay line5 check: Status of raw frontend delay line5 check delay line error.  "
bitfld.long 0x00 20. " Status iridix delay line check delay line error  , Iridix delay line check: Status of iridix delay line check delay line error.  "
bitfld.long 0x00 21. " Status out format uv delay line check delay line error  , Out format uv delay line check: Status of out format uv delay line check delay line error.  "
bitfld.long 0x00 22. " Status out format ab delay line check delay line error  , Out format ab delay line check: Status of out format ab delay line check delay line error.  "
textline "                 "
bitfld.long 0x00 23. " Status sinter delay line check delay line error  , Sinter delay line check: Status of sinter delay line check delay line error.  "
bitfld.long 0x00 24. " Status interrupts error interrupt double  , Interrupts: Status of interrupts error interrupt double.  "
hexmask.long.word 0x00 27.--31. 1. " Status arb hist error access out of range  ,Arb hist: Status of arb hist error access out of range."
TREE.END
TREE "uroi mem"
group.long 0x4000++0x4
line.long 0x0 "0x4000"
button "Data 0x04000" "B::Data.dump (0xFEC04000) /DIALOG"
TREE.END
TREE "cmd queues"
group.long 0x7c00++0x4
line.long 0x0 "0x7c00"
button "Data 0x07c00" "B::Data.dump (0xFEC07C00) /DIALOG"
TREE.END
TREE "histogram mem"
group.long 0x8000++0x4
line.long 0x0 "0x8000"
button "Data 0x08000" "B::Data.dump (0xFEC08000) /DIALOG"
TREE.END
TREE "metering mem"
group.long 0xd000++0x4
line.long 0x0 "0xd000"
button "Data 0x0d000" "B::Data.dump (0xFEC0D000) /DIALOG"
TREE.END
TREE "ID"
rgroup.long 0xe000++0x3
line.long 0x00 "0xe000"
hexmask.long.long 0x00 0.--31. 1. " API  ,"
rgroup.long 0xe004++0x3
line.long 0x00 "0xe004"
hexmask.long.long 0x00 0.--31. 1. " Product  ,"
rgroup.long 0xe008++0x3
line.long 0x00 "0xe008"
hexmask.long.long 0x00 0.--31. 1. " Version  ,"
rgroup.long 0xe00c++0x3
line.long 0x00 "0xe00c"
hexmask.long.long 0x00 0.--31. 1. " Revision  ,"
TREE.END
TREE "Top"
group.long 0xe010++0x3
line.long 0x00 "0xe010"
hexmask.long.word 0x00 0.--15. 1. " Active Width  ,Active video width in pixels"
group.long 0xe014++0x3
line.long 0x00 "0xe014"
hexmask.long.word 0x00 0.--15. 1. " Active Height  ,Active video height in lines"
group.long 0xe018++0x3
line.long 0x00 "0xe018"
hexmask.long.byte 0x00 0.--1. 1. " RGGB start  ,Starting color of the rggb pattern (0=R Gr   Gb B, 1=Gr R   B Gb, 2=Gb B   R Gr, 3=B Gb   Gr R)"
hexmask.long.byte 0x00 8.--9. 1. " CFA pattern  ,Pattern select: (0=RGGB, 1=RCCC, 2=RIrGB, 3=RGIrB)"
TREE.END
TREE "Pipeline"
group.long 0xe020++0x3
line.long 0x00 "0xe020"
hexmask.long.byte 0x00 0.--1. 1. " channel1 select  ,Source select for channel 1 through VTPG and Raw FE (0=Input Channel 1, 1=Input Channel 2, 2=Input Channel 3, 3=Input Channel 4)"
hexmask.long.byte 0x00 2.--3. 1. " channel2 select  ,Source select for channel 2 through VTPG and Raw FE (0=Input Channel 1, 1=Input Channel 2, 2=Input Channel 3, 3=Input Channel 4)"
hexmask.long.byte 0x00 4.--5. 1. " channel3 select  ,Source select for channel 3 through VTPG and Raw FE (0=Input Channel 1, 1=Input Channel 2, 2=Input Channel 3, 3=Input Channel 4)"
hexmask.long.byte 0x00 6.--7. 1. " channel4 select  ,Source select for channel 4 through VTPG and Raw FE (0=Input Channel 1, 1=Input Channel 2, 2=Input Channel 3, 3=Input Channel 4)"
group.long 0xe02c++0x3
line.long 0x00 "0xe02c"
hexmask.long.byte 0x00 0.--1. 1. " fs channel1 select  ,Source select for channel 1 into Frame Stitch (0=Frontend Channel 1, 1=Frontend Channel 2, 2=Frontend Channel 3, 3=Frontend Channel 4)"
hexmask.long.byte 0x00 2.--3. 1. " fs channel2 select  ,Source select for channel 2 into Frame Stitch (0=Frontend Channel 1, 1=Frontend Channel 2, 2=Frontend Channel 3, 3=Frontend Channel 4)"
hexmask.long.byte 0x00 4.--5. 1. " fs channel3 select  ,Source select for channel 3 into Frame Stitch (0=Frontend Channel 1, 1=Frontend Channel 2, 2=Frontend Channel 3, 3=Frontend Channel 4)"
hexmask.long.byte 0x00 6.--7. 1. " fs channel4 select  ,Source select for channel 4 into Frame Stitch (0=Frontend Channel 1, 1=Frontend Channel 2, 2=Frontend Channel 3, 3=Frontend Channel 4)"
group.long 0xe024++0x3
line.long 0x00 "0xe024"
hexmask.long.byte 0x00 0.--1. 1. " Delay line memory configuration  ,Memory configuration of Sinter delay lines. 00 = Maximum number of lines, shortest line length. 01 = 3/4 of maximum lines, 4/3 x shortest line. 1x = 1/2 of maximum lines, 2 x shortest line."
group.long 0xe028++0x3
line.long 0x00 "0xe028"
hexmask.long.word 0x00 0.--15. 1. " Flush hblank  ,Horizontal blanking interval during regeneration (0=measured input interval)"
group.long 0xe030++0x3
line.long 0x00 "0xe030"
hexmask.long.byte 0x00 0.--1. 1. " Config Buffer Mode  ,Select ISP configuration double-buffering mode (0=Disabled (config updates immediately), 1=Blocked (config never updates), 2=Local (module config updates during local vertical blanking), 3=Global (all module config updated during ISP vertical blanking))"
group.long 0xe040++0x3
line.long 0x00 "0xe040"
textline "                 "
bitfld.long 0x00 2. " Bypass input formatter  , Bypass input formatter module.  "
bitfld.long 0x00 3. " Bypass channel switch  , Bypass channel switch module  "
bitfld.long 0x00 4. " Bypass video test gen  , Bypass video test generator  "
bitfld.long 0x00 5. " Bypass RAW frontend  , Bypass RAW frontend (green equalization and dynamic defect pixel)  "
textline "                 "
bitfld.long 0x00 6. " Bypass defect pixel  , Bypass static defect pixel  "
bitfld.long 0x00 11. " Bypass FS channel switch  , Bypass frame stitch channel switch  "
bitfld.long 0x00 7. " Bypass frame stitch  , Bypass frame stitching logic  "
bitfld.long 0x00 8. " Bypass gamma fe  , Bypass front end gamma LUTs  "
textline "                 "
bitfld.long 0x00 9. " Bypass gamma fe dl  , Bypass front end gamma block  "
bitfld.long 0x00 10. " Bypass digital gain  , Bypass digital gain module  "
bitfld.long 0x00 21. " Bypass digital gain Iridix  , Bypass digital gain Iridix module  "
bitfld.long 0x00 12. " Bypass sinter  , Bypass Sinter  "
textline "                 "
bitfld.long 0x00 13. " Bypass gamma be  , Bypass back end end gamma LUTs  "
bitfld.long 0x00 14. " Bypass gamma be dl  , Bypass back end gamma block  "
bitfld.long 0x00 15. " Bypass white balance  , Bypass static white balance  "
bitfld.long 0x00 16. " Bypass radial shading  , Bypass Radial Shading  "
textline "                 "
bitfld.long 0x00 17. " Bypass mesh shading  , Bypass Mesh Shading  "
bitfld.long 0x00 18. " Bypass iridix  , Bypass Iridix  "
bitfld.long 0x00 19. " Bypass demosaic  , Bypass demosaic module (output RAW data)  "
bitfld.long 0x00 20. " Bypass out format  , Bypass color matrix  "
textline "                 "
bitfld.long 0x00 24. " Bypass crop  , Bypass cropping block  "
bitfld.long 0x00 27. " Bypass sensor offset WDR  , Bypass WDR sensor offset  "
bitfld.long 0x00 31. " Bypass sensor offset linear  , Bypass sensor offset in linear domain  "
bitfld.long 0x00 28. " Bypass WDR gain  , Bypass WDR gain  "
textline "                 "
bitfld.long 0x00 29. " Bypass CA correction  , Bypass CA correction  "
bitfld.long 0x00 30. " Linear data source  , Source for linear data in the pipeline (0=Frame stitch, 1=Decompanded sensor data)  "
group.long 0xe044++0x3
line.long 0x00 "0xe044"
hexmask.long.byte 0x00 12.--13. 1. " ISP RAW output data select  ,Source for raw data output in the output mux (0=Companded sensor data, 1=Frame stitch, 2=Post gamma FE companding curve, 3=Tone mapped data)"
hexmask.long.byte 0x00 8.--9. 1. " ISP RAW bypass  ,Used to select between normal ISP processing with image sensor data and up to 12 bit RGB or YUV422 input. In the latter case data is reinserted into pipeline after demosaic block. Crop, Scaling, Gamma and color space conversion are available for RGB input only. (0=Select processed., 1=Bypass ISP RAW processing., 2=Bypass input formatting., 3=Bypass multichannel frontend.)"
group.long 0xe048++0x3
line.long 0x00 "0xe048"
hexmask.long.byte 0x00 0.--2. 1. " AE switch  ,AE tap in the pipeline.  Location of AE statistic collection. (0=After static white balance, 1=After WDR gain, 2=After shading, 3=After WDR Frame Stitch, 4=After Frontend gamma, 5=Off, 6=Reserved 6, 7=Reserved 7)"
group.long 0xe04c++0x3
line.long 0x00 "0xe04c"
textline "                 "
bitfld.long 0x00 0. " AWB switch  , AWB tap in the pipeline.  Location of AWB statistics collection. (0=Immediately before colour matrix, 1=Immediately after colour Matrix)  "
group.long 0xe050++0x3
line.long 0x00 "0xe050"
hexmask.long.byte 0x00 0.--1. 1. " Histogram1 ISP switch  ,Location of the channel 1 histogram tap in ISP (0=ISP input 1, 1=Combined data, 2=Companded data, 3=After Shading)"
hexmask.long.byte 0x00 8.--9. 1. " Histogram2 ISP switch  ,Location of the channel 2 histogram tap in ISP (0=ISP input 2, 1=Combined data, 2=Companded data, 3=After Shading)"
hexmask.long.byte 0x00 16.--17. 1. " Histogram3 ISP switch  ,Location of the channel 3 histogram tap in ISP (0=ISP input 3, 1=Combined data, 2=Companded data, 3=After Shading)"
hexmask.long.byte 0x00 24.--25. 1. " Histogram4 ISP switch  ,Location of the channel 4 histogram tap in ISP (0=ISP input 4, 1=Combined data, 2=Companded data, 3=After Shading)"
group.long 0xe054++0x3
line.long 0x00 "0xe054"
textline "                 "
bitfld.long 0x00 0. " ROI Histogram switch  , Location of the ROI histogram tap in ISP (0=Linear stitched data, 1=After companding)  "
group.long 0xe058++0x3
line.long 0x00 "0xe05a"
bitfld.long 0x00 16. " Antifog Hist Switch  , Antifog histogram enable.  Enables statistics gathering for antifog global histogram (0=Enabled, 1=Disabled)  "
group.long 0xe060++0x3
line.long 0x00 "0xe060"
hexmask.long.byte 0x00 0.--2. 1. " Output tag  ,Tag for output streams"
group.long 0xe064++0x3
line.long 0x00 "0xe064"
hexmask.long.byte 0x00 0.--2. 1. " Context no  ,"
TREE.END
TREE "Test mode"
group.long 0xe070++0x3
line.long 0x00 "0xe070"
hexmask.long.byte 0x00 0.--7. 1. " Raw frontend  ,Test mode selector for Raw frontend"
hexmask.long.word 0x00 8.--16. 1. " Frame stitch  ,Test mode selector for Frame stitch"
hexmask.long.byte 0x00 24.--31. 1. " Sinter  ,Test mode selector for Sinter"
group.long 0xe074++0x3
line.long 0x00 "0xe074"
hexmask.long.byte 0x00 0.--7. 1. " Gamma FeDl  ,Test mode selector for Gamma fe"
hexmask.long.byte 0x00 8.--15. 1. " Gamma BeDl  ,Test mode selector for Gamma be"
hexmask.long.byte 0x00 16.--23. 1. " Radial shading  ,Test mode selector for Radial shading"
hexmask.long.byte 0x00 24.--31. 1. " Iridix  ,Test mode selector for Iridix"
group.long 0xe078++0x3
line.long 0x00 "0xe078"
hexmask.long.byte 0x00 0.--7. 1. " Demosaic  ,Test mode selector for Demosaic"
hexmask.long.byte 0x00 8.--15. 1. " Demosaic RGBIr  ,Test mode selector for Demosaic RGBIr"
hexmask.long.byte 0x00 16.--23. 1. " Demosaic RCCC  ,Test mode selector for Demosaic RCCC"
hexmask.long.byte 0x00 24.--31. 1. " Out format  ,Test mode selector for Out formatter"
group.long 0xe07c++0x3
line.long 0x00 "0xe07f"
textline "                 "
bitfld.long 0x00 24. " Test trigger  , Trigger test mode patterns manually  "
bitfld.long 0x00 28. " ISP Output CRC enable  ,   "
TREE.END
TREE "PC FIFO"
group.long 0xe080++0x3
line.long 0x00 "0xe080"
textline "                 "
bitfld.long 0x00 0. " Enable dynamic defects  , Enable dynamic defect flag bit plane  "
bitfld.long 0x00 1. " Enable static defects  , Enable static defect flag bit plane  "
bitfld.long 0x00 2. " Enable WDR inconsistency  , Enable WDR inconsistency bit plane  "
bitfld.long 0x00 3. " Enable WDR flicker  , Enable WDR flicker bit plane  "
group.long 0xe084++0x3
line.long 0x00 "0xe084"
textline "                 "
bitfld.long 0x00 0. " Counter overflow dynamic defects  , Overflow flag for dynamic defect pixel counter.  "
bitfld.long 0x00 1. " Counter overflow static defects  , Overflow flag for static defect pixel counter.  "
bitfld.long 0x00 2. " Counter overflow wdr inconsistency  , Overflow flag for WDR inconsistency counter.  "
bitfld.long 0x00 3. " Counter overflow wdr flicker  , Overflow flag for WDR flicker counter.  "
rgroup.long 0xe088++0x3
line.long 0x00 "0xe088"
hexmask.long.long 0x00 0.--31. 1. " Counter dynamic defects  ,Count of the dynamic defect pixels in the last frame."
rgroup.long 0xe08c++0x3
line.long 0x00 "0xe08c"
hexmask.long.long 0x00 0.--31. 1. " Counter static defects  ,Count of the static defect pixels in the last frame."
rgroup.long 0xe090++0x3
line.long 0x00 "0xe090"
hexmask.long.long 0x00 0.--31. 1. " Counter wdr inconsistency  ,Count of pixels with WDR inconsistency during frame stitch in the last frame."
rgroup.long 0xe094++0x3
line.long 0x00 "0xe094"
hexmask.long.long 0x00 0.--31. 1. " Counter wdr flicker  ,Count of the pixels with detected flicker in the last frame."
group.long 0xe080++0x3
line.long 0x00 "0xe081"
textline "                 "
bitfld.long 0x00 8. " Stat hold  ,   "
TREE.END
TREE "Input Formatter"
group.long 0xe140++0x3
line.long 0x00 "0xe140"
hexmask.long.byte 0x00 0.--2. 1. " mode in  ,Input mode (0=Linear data across 2 inputs, 1=2:3 multiple exposure multiplexing, 2=Logarithmic encoding, 3=Companding curve with knee points, 4=Reserved 4, 5=Reserved 5, 6=Reserved 6, 7=Reserved 7)"
hexmask.long.byte 0x00 16.--18. 1. " input bitwidth select  ,Input bitwidth select (0=8 bits, 1=10 bits, 2=12 bits, 3=14 bits, 4=16 bits, 5=20 bits (no 18 bits), 6=22 bits, 7=24 bits)"
textline "                 "
bitfld.long 0x00 24. " input alignment  , 0=LSB aligned 1=MSB aligned  "
group.long 0xe144++0x3
line.long 0x00 "0xe144"
hexmask.long.long 0x00 0.--17. 1. " factor ML  ,18 bit, 6.12 fix point - ratio between long and medium exposure for 2:3 multiplexed mode"
group.long 0xe148++0x3
line.long 0x00 "0xe148"
hexmask.long.word 0x00 0.--12. 1. " factor MS  ,13 bit, 1.12 fix point - ratio between short and medium exposure for 2:3 multiplexed mode"
group.long 0xe14c++0x3
line.long 0x00 "0xe14c"
hexmask.long.word 0x00 0.--11. 1. " black level  ,Black level of sensor data for 2:3 multiplexed mode"
group.long 0xe150++0x3
line.long 0x00 "0xe150"
hexmask.long.word 0x00 0.--15. 1. " knee point0  ,First knee point"
hexmask.long.word 0x00 16.--31. 1. " knee point1  ,Second knee point"
group.long 0xe154++0x3
line.long 0x00 "0xe154"
hexmask.long.word 0x00 0.--15. 1. " knee point2  ,Third knee point"
group.long 0xe158++0x3
line.long 0x00 "0xe158"
hexmask.long.byte 0x00 0.--3. 1. " slope0 select  ,First slope for companding table segments (0=1x, 1=2x, 2=4x, 3=8x, 4=16x, 5=32x, 6=64x, 7=128x, 8=256x, 9=512x, 10=1024x, 11=2048x, 12=4096x, 13=8192x, 14=16384x, 15=32768x)"
hexmask.long.byte 0x00 8.--11. 1. " slope1 select  ,Second slope for companding table segments (encoding is the same as slope0 select)"
hexmask.long.byte 0x00 16.--19. 1. " slope2 select  ,Third slope for companding table segments (encoding is the same as slope0 select)"
hexmask.long.byte 0x00 24.--27. 1. " slope3 select  ,Last slope for companding table segments (encoding is the same as slope0 select)"
TREE.END
TREE "video test gen"
group.long 0xe160++0x3
line.long 0x00 "0xe160"
textline "                 "
bitfld.long 0x00 0. " test_pattern_off on  , Test pattern off-on: 0=off, 1=on  "
bitfld.long 0x00 1. " bayer_rgb_i sel  , Bayer or rgb select for input video: 0=bayer, 1=rgb  "
bitfld.long 0x00 2. " bayer_rgb_o sel  , Bayer or rgb select for output video: 0=bayer, 1=rgb  "
hexmask.long.byte 0x00 8.--15. 1. " pattern type  ,Pattern type select: 0=Flat field,1=Horizontal gradient,2=Vertical Gradient,3=Vertical Bars,4=Rectangle,5-random,6-255=Default white frame on black"
textline "                 "
bitfld.long 0x00 3. " prbs rst on frame  ,   "
bitfld.long 0x00 4. " Generate mode  ,   "
bitfld.long 0x00 5. " Video source  ,   "
group.long 0xe164++0x3
line.long 0x00 "0xe164"
bitfld.long 0x00 0. " Frame request  , Request autogenerated frame  "
group.long 0xe168++0x3
line.long 0x00 "0xe168"
hexmask.long.long 0x00 0.--19. 1. " r backgnd  ,Red background  value 16-bit, MSB aligned to used width"
group.long 0xe16c++0x3
line.long 0x00 "0xe16c"
hexmask.long.long 0x00 0.--19. 1. " g backgnd  ,Green background value 16-bit, MSB aligned to used width"
group.long 0xe170++0x3
line.long 0x00 "0xe170"
hexmask.long.long 0x00 0.--19. 1. " b backgnd  ,Blue background value 16-bit, MSB aligned to used width"
group.long 0xe174++0x3
line.long 0x00 "0xe174"
hexmask.long.long 0x00 0.--19. 1. " ir backgnd  ,IR background value 16-bit, MSB aligned to used width"
group.long 0xe178++0x3
line.long 0x00 "0xe178"
hexmask.long.long 0x00 0.--19. 1. " r foregnd  ,Red foreground  value 16-bit, MSB aligned to used width"
group.long 0xe17c++0x3
line.long 0x00 "0xe17c"
hexmask.long.long 0x00 0.--19. 1. " g foregnd  ,Green foreground value 16-bit, MSB aligned to used width"
group.long 0xe180++0x3
line.long 0x00 "0xe180"
hexmask.long.long 0x00 0.--19. 1. " b foregnd  ,Blue foreground value 16-bit, MSB aligned to used width"
group.long 0xe184++0x3
line.long 0x00 "0xe184"
hexmask.long.long 0x00 0.--19. 1. " ir foregnd  ,IR foreground value 16-bit, MSB aligned to used width"
group.long 0xe188++0x3
line.long 0x00 "0xe188"
hexmask.long.word 0x00 0.--15. 1. " rgb gradient 1  ,RGB gradient increment per pixel (0-15) for first channel"
hexmask.long.word 0x00 16.--31. 1. " rgb gradient 2  ,RGB gradient increment for channel 2"
group.long 0xe18c++0x3
line.long 0x00 "0xe18c"
hexmask.long.word 0x00 0.--15. 1. " rgb gradient 3  ,RGB gradient increment for channel 3"
hexmask.long.word 0x00 16.--31. 1. " rgb gradient 4  ,RGB gradient increment for channel 4"
group.long 0xe190++0x3
line.long 0x00 "0xe190"
hexmask.long.long 0x00 0.--19. 1. " rgb_gradient start 1  ,RGB gradient start value for first channel 16-bit, MSB aligned to used width"
group.long 0xe194++0x3
line.long 0x00 "0xe194"
hexmask.long.long 0x00 0.--19. 1. " rgb_gradient start 2  ,RGB gradient start value for first channel 2"
group.long 0xe198++0x3
line.long 0x00 "0xe198"
hexmask.long.long 0x00 0.--19. 1. " rgb_gradient start 3  ,RGB gradient start value for first channel 3"
group.long 0xe19c++0x3
line.long 0x00 "0xe19c"
hexmask.long.long 0x00 0.--19. 1. " rgb_gradient start 4  ,RGB gradient start value for first channel 4"
group.long 0xe1a0++0x3
line.long 0x00 "0xe1a0"
hexmask.long.word 0x00 0.--13. 1. " rect top  ,Rectangle top line number 1-n"
hexmask.long.word 0x00 16.--29. 1. " rect bot  ,Rectangle bottom line number 1-n"
group.long 0xe1a4++0x3
line.long 0x00 "0xe1a4"
hexmask.long.word 0x00 0.--13. 1. " rect left  ,Rectangle left pixel number 1-n"
hexmask.long.word 0x00 16.--29. 1. " rect right  ,Rectangle right pixel number 1-n"
group.long 0xe1a8++0x3
line.long 0x00 "0xe1a8"
hexmask.long.long 0x00 0.--30. 1. " PRBS seed 1  ,PRBS seed. The PRBS LFSR is seeded with this value when reset on a frame boundary."
group.long 0xe1ac++0x3
line.long 0x00 "0xe1ac"
hexmask.long.long 0x00 0.--30. 1. " PRBS seed 2  ,PRBS seed. The PRBS LFSR is seeded with this value when reset on a frame boundary."
group.long 0xe1b0++0x3
line.long 0x00 "0xe1b0"
hexmask.long.long 0x00 0.--30. 1. " PRBS seed 3  ,PRBS seed. The PRBS LFSR is seeded with this value when reset on a frame boundary."
group.long 0xe1b4++0x3
line.long 0x00 "0xe1b4"
hexmask.long.long 0x00 0.--30. 1. " PRBS seed 4  ,PRBS seed. The PRBS LFSR is seeded with this value when reset on a frame boundary."
group.long 0xe1b8++0x3
line.long 0x00 "0xe1b8"
hexmask.long.word 0x00 0.--13. 1. " Horizontal blanking  ,Horizontal blank for autogenerated frame"
group.long 0xe1bc++0x3
line.long 0x00 "0xe1bc"
hexmask.long.word 0x00 0.--13. 1. " Vertical blanking  ,Vertical blank for autogenerated frame"
TREE.END
TREE "Sensor Offset linear"
group.long 0xe1f0++0x3
line.long 0x00 "0xe1f0"
hexmask.long.long 0x00 0.--23. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xe1f4++0x3
line.long 0x00 "0xe1f4"
hexmask.long.long 0x00 0.--23. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xe1f8++0x3
line.long 0x00 "0xe1f8"
hexmask.long.long 0x00 0.--23. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xe1fc++0x3
line.long 0x00 "0xe1fc"
hexmask.long.long 0x00 0.--23. 1. " Black 11  ,Black offset for color channel 11 (B)"
TREE.END
TREE "Sensor Offset WDR 1"
group.long 0xe0c0++0x3
line.long 0x00 "0xe0c0"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xe0c4++0x3
line.long 0x00 "0xe0c4"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xe0c8++0x3
line.long 0x00 "0xe0c8"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xe0cc++0x3
line.long 0x00 "0xe0cc"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
TREE.END
TREE "Sensor Offset WDR 2"
group.long 0xe0d0++0x3
line.long 0x00 "0xe0d0"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xe0d4++0x3
line.long 0x00 "0xe0d4"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xe0d8++0x3
line.long 0x00 "0xe0d8"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xe0dc++0x3
line.long 0x00 "0xe0dc"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
TREE.END
TREE "Sensor Offset WDR 3"
group.long 0xe0e0++0x3
line.long 0x00 "0xe0e0"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xe0e4++0x3
line.long 0x00 "0xe0e4"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xe0e8++0x3
line.long 0x00 "0xe0e8"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xe0ec++0x3
line.long 0x00 "0xe0ec"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
TREE.END
TREE "Sensor Offset WDR 4"
group.long 0xe0f0++0x3
line.long 0x00 "0xe0f0"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xe0f4++0x3
line.long 0x00 "0xe0f4"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xe0f8++0x3
line.long 0x00 "0xe0f8"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xe0fc++0x3
line.long 0x00 "0xe0fc"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
TREE.END
TREE "WDR Gain"
group.long 0xe0a0++0x3
line.long 0x00 "0xe0a0"
hexmask.long.word 0x00 0.--12. 1. " Gain WDR1  ,Gain applied to ch1 data in 5.8 format"
hexmask.long.word 0x00 16.--28. 1. " Gain WDR2  ,Gain applied to ch2 data in 5.8 format"
group.long 0xe0a4++0x3
line.long 0x00 "0xe0a4"
hexmask.long.word 0x00 0.--12. 1. " Gain WDR3  ,Gain applied to ch3 data in 5.8 format"
hexmask.long.word 0x00 16.--28. 1. " Gain WDR4  ,Gain applied to ch4 data in 5.8 format"
group.long 0xe0a8++0x3
line.long 0x00 "0xe0a8"
hexmask.long.long 0x00 0.--19. 1. " Offset WDR1  ,Sensor offset applied to ch1 data"
group.long 0xe0ac++0x3
line.long 0x00 "0xe0ac"
hexmask.long.long 0x00 0.--19. 1. " Offset WDR2  ,Sensor offset applied to ch2 data"
group.long 0xe0b0++0x3
line.long 0x00 "0xe0b0"
hexmask.long.long 0x00 0.--19. 1. " Offset WDR3  ,Sensor offset applied to ch3 data"
group.long 0xe0b4++0x3
line.long 0x00 "0xe0b4"
hexmask.long.long 0x00 0.--19. 1. " Offset WDR4  ,Sensor offset applied to ch4 data"
TREE.END
TREE "Noise Profile RAW frontend"
group.long 0xfa80++0x80
line.quad 0x00 "0xfa80"
hexmask.long.byte 0x0 0.--7. 1. " Noise Profile RAW frontend LUT Weight lut[0] , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.long.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.long.byte 0x4 8.--15. 1. "  [5]  , "
hexmask.long.byte 0x4 16.--23. 1. "  [6]  , "
hexmask.long.byte 0x4 24.--31. 1. "  [7]  , "
hexmask.long.byte 0x8 0.--7. 1. "  [8]  , "
hexmask.long.byte 0x8 8.--15. 1. "  [9]  , "
hexmask.long.byte 0x8 16.--23. 1. "  [10] , "
hexmask.long.byte 0x8 24.--31. 1. "  [11] , "
hexmask.long.byte 0xc 0.--7. 1. "  [12] , "
hexmask.long.byte 0xc 8.--15. 1. "  [13] , "
hexmask.long.byte 0xc 16.--23. 1. "  [14] , "
hexmask.long.byte 0xc 24.--31. 1. "  [15] , "
hexmask.long.byte 0x10 0.--7. 1. "  [16] , "
hexmask.long.byte 0x10 8.--15. 1. "  [17] , "
hexmask.long.byte 0x10 16.--23. 1. "  [18] , "
hexmask.long.byte 0x10 24.--31. 1. "  [19] , "
hexmask.long.byte 0x14 0.--7. 1. "  [20] , "
hexmask.long.byte 0x14 8.--15. 1. "  [21] , "
hexmask.long.byte 0x14 16.--23. 1. "  [22] , "
hexmask.long.byte 0x14 24.--31. 1. "  [23] , "
hexmask.long.byte 0x18 0.--7. 1. "  [24] , "
hexmask.long.byte 0x18 8.--15. 1. "  [25] , "
hexmask.long.byte 0x18 16.--23. 1. "  [26] , "
hexmask.long.byte 0x18 24.--31. 1. "  [27] , "
hexmask.long.byte 0x1c 0.--7. 1. "  [28] , "
hexmask.long.byte 0x1c 8.--15. 1. "  [29] , "
hexmask.long.byte 0x1c 16.--23. 1. "  [30] , "
hexmask.long.byte 0x1c 24.--31. 1. "  [31] , "
hexmask.long.byte 0x20 0.--7. 1. "  [32] , "
hexmask.long.byte 0x20 8.--15. 1. "  [33] , "
hexmask.long.byte 0x20 16.--23. 1. "  [34] , "
hexmask.long.byte 0x20 24.--31. 1. "  [35] , "
hexmask.long.byte 0x24 0.--7. 1. "  [36] , "
hexmask.long.byte 0x24 8.--15. 1. "  [37] , "
hexmask.long.byte 0x24 16.--23. 1. "  [38] , "
hexmask.long.byte 0x24 24.--31. 1. "  [39] , "
hexmask.long.byte 0x28 0.--7. 1. "  [40] , "
hexmask.long.byte 0x28 8.--15. 1. "  [41] , "
hexmask.long.byte 0x28 16.--23. 1. "  [42] , "
hexmask.long.byte 0x28 24.--31. 1. "  [43] , "
hexmask.long.byte 0x2c 0.--7. 1. "  [44] , "
hexmask.long.byte 0x2c 8.--15. 1. "  [45] , "
hexmask.long.byte 0x2c 16.--23. 1. "  [46] , "
hexmask.long.byte 0x2c 24.--31. 1. "  [47] , "
hexmask.long.byte 0x30 0.--7. 1. "  [48] , "
hexmask.long.byte 0x30 8.--15. 1. "  [49] , "
hexmask.long.byte 0x30 16.--23. 1. "  [50] , "
hexmask.long.byte 0x30 24.--31. 1. "  [51] , "
hexmask.long.byte 0x34 0.--7. 1. "  [52] , "
hexmask.long.byte 0x34 8.--15. 1. "  [53] , "
hexmask.long.byte 0x34 16.--23. 1. "  [54] , "
hexmask.long.byte 0x34 24.--31. 1. "  [55] , "
hexmask.long.byte 0x38 0.--7. 1. "  [56] , "
hexmask.long.byte 0x38 8.--15. 1. "  [57] , "
hexmask.long.byte 0x38 16.--23. 1. "  [58] , "
hexmask.long.byte 0x38 24.--31. 1. "  [59] , "
hexmask.long.byte 0x3c 0.--7. 1. "  [60] , "
hexmask.long.byte 0x3c 8.--15. 1. "  [61] , "
hexmask.long.byte 0x3c 16.--23. 1. "  [62] , "
hexmask.long.byte 0x3c 24.--31. 1. "  [63] , "
hexmask.long.byte 0x40 0.--7. 1. "  [64] , "
hexmask.long.byte 0x40 8.--15. 1. "  [65] , "
hexmask.long.byte 0x40 16.--23. 1. "  [66] , "
hexmask.long.byte 0x40 24.--31. 1. "  [67] , "
hexmask.long.byte 0x44 0.--7. 1. "  [68] , "
hexmask.long.byte 0x44 8.--15. 1. "  [69] , "
hexmask.long.byte 0x44 16.--23. 1. "  [70] , "
hexmask.long.byte 0x44 24.--31. 1. "  [71] , "
hexmask.long.byte 0x48 0.--7. 1. "  [72] , "
hexmask.long.byte 0x48 8.--15. 1. "  [73] , "
hexmask.long.byte 0x48 16.--23. 1. "  [74] , "
hexmask.long.byte 0x48 24.--31. 1. "  [75] , "
hexmask.long.byte 0x4c 0.--7. 1. "  [76] , "
hexmask.long.byte 0x4c 8.--15. 1. "  [77] , "
hexmask.long.byte 0x4c 16.--23. 1. "  [78] , "
hexmask.long.byte 0x4c 24.--31. 1. "  [79] , "
hexmask.long.byte 0x50 0.--7. 1. "  [80] , "
hexmask.long.byte 0x50 8.--15. 1. "  [81] , "
hexmask.long.byte 0x50 16.--23. 1. "  [82] , "
hexmask.long.byte 0x50 24.--31. 1. "  [83] , "
hexmask.long.byte 0x54 0.--7. 1. "  [84] , "
hexmask.long.byte 0x54 8.--15. 1. "  [85] , "
hexmask.long.byte 0x54 16.--23. 1. "  [86] , "
hexmask.long.byte 0x54 24.--31. 1. "  [87] , "
hexmask.long.byte 0x58 0.--7. 1. "  [88] , "
hexmask.long.byte 0x58 8.--15. 1. "  [89] , "
hexmask.long.byte 0x58 16.--23. 1. "  [90] , "
hexmask.long.byte 0x58 24.--31. 1. "  [91] , "
hexmask.long.byte 0x5c 0.--7. 1. "  [92] , "
hexmask.long.byte 0x5c 8.--15. 1. "  [93] , "
hexmask.long.byte 0x5c 16.--23. 1. "  [94] , "
hexmask.long.byte 0x5c 24.--31. 1. "  [95] , "
hexmask.long.byte 0x60 0.--7. 1. "  [96] , "
hexmask.long.byte 0x60 8.--15. 1. "  [97] , "
hexmask.long.byte 0x60 16.--23. 1. "  [98] , "
hexmask.long.byte 0x60 24.--31. 1. "  [99] , "
hexmask.long.byte 0x64 0.--7. 1. "  [100] , "
hexmask.long.byte 0x64 8.--15. 1. "  [101] , "
hexmask.long.byte 0x64 16.--23. 1. "  [102] , "
hexmask.long.byte 0x64 24.--31. 1. "  [103] , "
hexmask.long.byte 0x68 0.--7. 1. "  [104] , "
hexmask.long.byte 0x68 8.--15. 1. "  [105] , "
hexmask.long.byte 0x68 16.--23. 1. "  [106] , "
hexmask.long.byte 0x68 24.--31. 1. "  [107] , "
hexmask.long.byte 0x6c 0.--7. 1. "  [108] , "
hexmask.long.byte 0x6c 8.--15. 1. "  [109] , "
hexmask.long.byte 0x6c 16.--23. 1. "  [110] , "
hexmask.long.byte 0x6c 24.--31. 1. "  [111] , "
hexmask.long.byte 0x70 0.--7. 1. "  [112] , "
hexmask.long.byte 0x70 8.--15. 1. "  [113] , "
hexmask.long.byte 0x70 16.--23. 1. "  [114] , "
hexmask.long.byte 0x70 24.--31. 1. "  [115] , "
hexmask.long.byte 0x74 0.--7. 1. "  [116] , "
hexmask.long.byte 0x74 8.--15. 1. "  [117] , "
hexmask.long.byte 0x74 16.--23. 1. "  [118] , "
hexmask.long.byte 0x74 24.--31. 1. "  [119] , "
hexmask.long.byte 0x78 0.--7. 1. "  [120] , "
hexmask.long.byte 0x78 8.--15. 1. "  [121] , "
hexmask.long.byte 0x78 16.--23. 1. "  [122] , "
hexmask.long.byte 0x78 24.--31. 1. "  [123] , "
hexmask.long.byte 0x7c 0.--7. 1. "  [124] , "
hexmask.long.byte 0x7c 8.--15. 1. "  [125] , "
hexmask.long.byte 0x7c 16.--23. 1. "  [126] , "
hexmask.long.byte 0x7c 24.--31. 1. "  [127] , "
group.long 0xe200++0x3
line.long 0x00 "0xe200"
hexmask.long.word 0x00 0.--15. 1. " Exp Thresh  ,Threshold for determining long/short exposure data"
group.long 0xe204++0x3
line.long 0x00 "0xe204"
hexmask.long.byte 0x00 0.--7. 1. " Short Ratio  ,Multiplier applied to short exposure data for noise profile calculation"
group.long 0xe208++0x3
line.long 0x00 "0xe208"
hexmask.long.byte 0x00 0.--7. 1. " Long Ratio  ,Multiplier applied to long exposure data for noise profile calculation"
group.long 0xe20c++0x3
line.long 0x00 "0xe20c"
hexmask.long.byte 0x00 0.--6. 1. " NP off  ,Noise profile black level offset"
textline "                 "
bitfld.long 0x00 7. " NP off reflect  , Defines how values below black level are obtained.           0: Repeat the first table entry.           1: Reflect the noise profile curve below black level.  "
TREE.END
TREE "RAW Frontend"
group.long 0xe210++0x3
line.long 0x00 "0xe210"
textline "                 "
bitfld.long 0x00 0. " ge enable  , Green equalization enable: 0=off, 1=on  "
bitfld.long 0x00 2. " dp enable  , Dynamic Defect Pixel enable: 0=off, 1=on  "
bitfld.long 0x00 3. " show dynamic defect pixel  , Show Defect Pixel: 0=off, 1=on  "
bitfld.long 0x00 6. " dark disable  , Disable detection of dark pixels  "
textline "                 "
bitfld.long 0x00 7. " bright disable  , Disable detection of bright pixels  "
bitfld.long 0x00 5. " RFE disable L2  , Disable L2 function  "
group.long 0xe214++0x3
line.long 0x00 "0xe214"
hexmask.long.byte 0x00 0.--7. 1. " ge strength  ,Controls strength of Green equalization.  Set during calibration."
group.long 0xe218++0x3
line.long 0x00 "0xe218"
hexmask.long.word 0x00 0.--15. 1. " debug sel  ,Debug selection port"
group.long 0xe21c++0x3
line.long 0x00 "0xe21c"
hexmask.long.word 0x00 0.--11. 1. " dp threshold  ,Defect pixel threshold."
group.long 0xe220++0x3
line.long 0x00 "0xe220"
hexmask.long.word 0x00 0.--15. 1. " ge threshold  ,Green equalization threshold"
group.long 0xe224++0x3
line.long 0x00 "0xe224"
hexmask.long.word 0x00 0.--11. 1. " dp slope  ,Slope for HP Mask function"
group.long 0xe228++0x3
line.long 0x00 "0xe228"
hexmask.long.word 0x00 0.--11. 1. " ge slope  ,Slope for GE Mask function"
group.long 0xe22c++0x3
line.long 0x00 "0xe22c"
hexmask.long.byte 0x00 0.--7. 1. " ge sens  ,Controls the sensitivity of green equalization to edges."
group.long 0xe230++0x3
line.long 0x00 "0xe230"
hexmask.long.word 0x00 0.--15. 1. " dpdev threshold  ,Controls the aggressiveness of the dynamic defect pixel correction near edges."
group.long 0xe234++0x3
line.long 0x00 "0xe234"
hexmask.long.word 0x00 0.--15. 1. " line thresh  ,Controls the directional nature of the dynamic defect pixel correction near edges.."
group.long 0xe238++0x3
line.long 0x00 "0xe238"
hexmask.long.byte 0x00 0.--7. 1. " dp blend  ,Controls blending between non-directional and directional replacement values in dynamic defect pixel correction.         0x00 Replace detected defects with non-directional replacement value         0xFF Replace detected defects with directional replacement value"
group.long 0xe23c++0x3
line.long 0x00 "0xe23c"
hexmask.long.word 0x00 0.--15. 1. " Sigma In  ,Manual override of noise estimation"
group.long 0xe240++0x3
line.long 0x00 "0xe240"
hexmask.long.byte 0x00 0.--7. 1. " Thresh Short  ,Noise threshold for short exposure data"
group.long 0xe244++0x3
line.long 0x00 "0xe244"
hexmask.long.byte 0x00 0.--7. 1. " Thresh Long  ,Noise threshold for long exposure data"
TREE.END
TREE "Defect Pixel"
group.long 0xe284++0x3
line.long 0x00 "0xe284"
textline "                 "
bitfld.long 0x00 0. " Pointer Reset  , Reset static defect-pixel table pointer each frame - set this when defect-pixel table has been written from mcu  "
bitfld.long 0x00 1. " Show Reference  , For debug purposes.  Show reference values which are compared with actual values to detect bad pixels  "
bitfld.long 0x00 2. " Enable  , Correction enable: 0=off 1=on  "
bitfld.long 0x00 3. " Show Static Defect Pixels  , Show which pixels have been detected as bad  "
textline "                 "
bitfld.long 0x00 4. " Detection Trigger  , Starts detection on 0-1 transition  "
group.long 0xe288++0x3
line.long 0x00 "0xe288"
bitfld.long 0x00 0. " Overflow  , Table overflow flag  "
rgroup.long 0xe28c++0x3
line.long 0x00 "0xe28c"
hexmask.long.word 0x00 0.--9. 1. " Defect Pixel Count  ,Number of defect-pixels detected"
rgroup.long 0xe290++0x3
line.long 0x00 "0xe290"
hexmask.long.word 0x00 0.--9. 1. " Table Start  ,Address of first defect-pixel in defect-pixel store"
group.long 0xe294++0x3
line.long 0x00 "0xe294"
hexmask.long.word 0x00 0.--9. 1. " Defect Pixel Count In  ,Number of defect-pixels in the written table"
rgroup.long 0xe298++0x3
line.long 0x00 "0xe298"
hexmask.long.long 0x00 0.--31. 1. " Dynamic Defect Count  ,Number of dynamic defect pixels in the last frame"
rgroup.long 0xe29c++0x3
line.long 0x00 "0xe29c"
hexmask.long.long 0x00 0.--31. 1. " Static Defect Count  ,Number of static defect pixels in the last frame"
TREE.END
TREE "WDR stitching"
group.long 0xe2a0++0x3
line.long 0x00 "0xe2a0"
hexmask.long.byte 0x00 0.--1. 1. " mode in  ,0 : 4-exposure                           1 : 2-exposure                           2 : 3-exposure                           3 : 4-exposure"
group.long 0xe2a4++0x3
line.long 0x00 "0xe2a4"
hexmask.long.byte 0x00 0.--7. 1. " output select  ,This register is only for debug purpose. for normal operation it must be kept in its default value (0)             0 : normal stitched output             1 : long data routed out             2 : medium data routed out             4 : short data routed out             8 : very short data routed out             16: LM stitched output taken out             32: MS stitched output taken out             64: SVS stitched output taken out             others: reserved"
group.long 0xe2a8++0x3
line.long 0x00 "0xe2a8"
hexmask.long.word 0x00 0.--11. 1. " LM Exposure Ratio  ,Sets ratio between long and medium exposures - this must match the actual exposure ratio on the sensor"
hexmask.long.word 0x00 16.--27. 1. " MS Exposure Ratio  ,Sets ratio between medium and short exposures - this must match the actual exposure ratio on the sensor"
group.long 0xe2ac++0x3
line.long 0x00 "0xe2ac"
hexmask.long.word 0x00 0.--11. 1. " SVS Exposure Ratio  ,Sets ratio between short and very short exposures - this must match the actual exposure ratio on the sensor"
group.long 0xe2b0++0x3
line.long 0x00 "0xe2b0"
hexmask.long.word 0x00 0.--15. 1. " LM Thresh high  ,These two thresholds are for LM pairs. Both are with respect to the longer stitches.             Data above this threshold will be taken from short exposure only"
hexmask.long.word 0x00 16.--31. 1. " LM Thresh low  ,Data below this threshold will be taken from long exposure only"
group.long 0xe2b4++0x3
line.long 0x00 "0xe2b4"
hexmask.long.word 0x00 0.--15. 1. " MS Thresh high  ,These two thresholds are for MS pairs. Both are with respect to the longer stitches.             Data above this threshold will be taken from short exposure only"
hexmask.long.word 0x00 16.--31. 1. " MS Thresh low  ,Data below this threshold will be taken from long exposure only"
group.long 0xe2b8++0x3
line.long 0x00 "0xe2b8"
hexmask.long.word 0x00 0.--15. 1. " SVS Thresh high  ,These two thresholds are for SVS pairs. Both are with respect to the longer stitches.             Data above this threshold will be taken from short exposure only"
hexmask.long.word 0x00 16.--31. 1. " SVS Thresh low  ,Data below this threshold will be taken from long exposure only"
group.long 0xe2bc++0x3
line.long 0x00 "0xe2bc"
hexmask.long.word 0x00 0.--15. 1. " LM Thresh median  ,This threshold is used only for the LM pair stitching. This determines if the short exposure for the blending             will be taken from the current pixel or the median value."
group.long 0xe2c0++0x3
line.long 0x00 "0xe2c0"
hexmask.long.word 0x00 0.--15. 1. " Black level long  ,Black level for long exposure input"
hexmask.long.word 0x00 16.--31. 1. " Black level Medium  ,Black level for medium exposure input             *** NOTE ***:             If the WDR unit is configured to use as 2-exposure, THIS REGISTER POSITION must contain the black level of             short exposure as the LM pair is used for all other configurations"
group.long 0xe2c4++0x3
line.long 0x00 "0xe2c4"
hexmask.long.word 0x00 0.--15. 1. " Black level Short  ,Black level for short exposure input"
hexmask.long.word 0x00 16.--31. 1. " Black level very Short  ,Black level for very short exposure input"
group.long 0xe2c8++0x3
line.long 0x00 "0xe2c8"
hexmask.long.long 0x00 0.--23. 1. " Black level Out  ,Black level for module output"
group.long 0xe2cc++0x3
line.long 0x00 "0xe2cc"
hexmask.long.word 0x00 0.--11. 1. " LM NP mult  ,The noise profile weights are multiplied by this value to give expected noise amplitude."
hexmask.long.word 0x00 16.--27. 1. " MS NP mult  ,The noise profile weights are multiplied by this value to give expected noise amplitude."
group.long 0xe2d0++0x3
line.long 0x00 "0xe2d0"
hexmask.long.word 0x00 16.--27. 1. " SVS NP mult  ,The noise profile weights are multiplied by this value to give expected noise amplitude."
group.long 0xe2d4++0x3
line.long 0x00 "0xe2d4"
hexmask.long.word 0x00 0.--11. 1. " LM Alpha MOV slope  ,This defines the gradient of the motion alpha ramp. Higher values mean a steeper ramp and so a more rapid transition between              non-motion-corrected and motion-corrected regions."
hexmask.long.word 0x00 16.--27. 1. " MS Alpha MOV slope  ,This defines the gradient of the motion alpha ramp. Higher values mean a steeper ramp and so a more rapid transition between              non-motion-corrected and motion-corrected regions."
group.long 0xe2d8++0x3
line.long 0x00 "0xe2d8"
hexmask.long.word 0x00 16.--27. 1. " SVS Alpha MOV slope  ,his defines the gradient of the motion alpha ramp. Higher values mean a steeper ramp and so a more rapid transition between              non-motion-corrected and motion-corrected regions."
group.long 0xe2dc++0x3
line.long 0x00 "0xe2dc"
hexmask.long.word 0x00 0.--11. 1. " Gain R  ,Multiplier for color channel R"
hexmask.long.word 0x00 16.--27. 1. " Gain B  ,Multiplier for color channel B"
group.long 0xe2e0++0x3
line.long 0x00 "0xe2e0"
hexmask.long.word 0x00 0.--11. 1. " Consistency thresh mov  ,Pixel consistency reporting - motion threshold"
group.long 0xe2e4++0x3
line.long 0x00 "0xe2e4"
hexmask.long.long 0x00 0.--23. 1. " Consistency thresh lvl  ,Pixel consistency reporting - flicker threshold"
TREE.END
TREE "Frontend LUT"
group.long 0xe2f0++0x3
line.long 0x00 "0xe2f0"
textline "                 "
bitfld.long 0x00 0. " Enable  , Frontend lookup0 enable: 0=off 1=on  "
bitfld.long 0x00 2. " Enable DL  , Frontend lookup1 enable: 0=off 1=on  "
group.long 0xe2f4++0x3
line.long 0x00 "0xe2f4"
hexmask.long.long 0x00 0.--24. 1. " Data Last  ,Frontend lookup1 enable: 0=off 1=on"
group.long 0xe2f8++0x3
line.long 0x00 "0xe2f8"
hexmask.long.long 0x00 0.--21. 1. " Alpha  ,Front end alpha 9.12 fix point"
group.long 0xe2fc++0x3
line.long 0x00 "0xe2fc"
hexmask.long.long 0x00 0.--23. 1. " Black level in DL  ,Frontend DL table input black level"
group.long 0xe300++0x3
line.long 0x00 "0xe300"
hexmask.long.long 0x00 0.--23. 1. " Black level out DL  ,Frontend DL table output black level"
TREE.END
TREE "Digital Gain"
group.long 0xe308++0x3
line.long 0x00 "0xe308"
hexmask.long.word 0x00 0.--12. 1. " Gain  ,Gain applied to data in 5.8 format"
group.long 0xe30c++0x3
line.long 0x00 "0xe30c"
hexmask.long.long 0x00 0.--23. 1. " Offset  ,Data black level"
TREE.END
TREE "Sinter"
group.long 0xe310++0x3
line.long 0x00 "0xe310"
textline "                 "
bitfld.long 0x00 4. " Enable  , Sinter enable: 0=off 1=on  "
hexmask.long.byte 0x00 0.--1. 1. " View Filter  ,For debug purposes only. Set to zero for normal operation"
hexmask.long.byte 0x00 2.--3. 1. " Scale Mode  ,For debug purposes only. Set to 3 for normal operation (0=Use filter 0 only, 1=Use filters 0 and 2 only, 2=Use filters 0, 2 and 4 only, 3=Use all filters)"
textline "                 "
bitfld.long 0x00 5. " Filter select  , Sinter filter fine tuning.  Should not be modified from suggested values.  "
bitfld.long 0x00 6. " Int select  , Select intensity filter.  Should not be modified from suggested values.  "
bitfld.long 0x00 7. " rm_enable  , Adjusts Sinter strength radially from center to compensate for Lens shading correction.           enable: 0=off, 1=on  "
hexmask.long.byte 0x00 8.--11. 1. " int config  ,Intensity blending with mosaic raw"
group.long 0xe314++0x3
line.long 0x00 "0xe314"
hexmask.long.word 0x00 0.--15. 1. " rm_center_x  ,Center x coordinate of shading map"
group.long 0xe318++0x3
line.long 0x00 "0xe318"
hexmask.long.word 0x00 0.--15. 1. " rm_center_y  ,Center y coordinate of shading map"
group.long 0xe31c++0x3
line.long 0x00 "0xe31c"
hexmask.long.word 0x00 0.--15. 1. " rm_off_center_mult  ,Normalizing factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xe320++0x3
line.long 0x00 "0xe320"
hexmask.long.byte 0x00 0.--7. 1. " Thresh 1h  ,Noise threshold for high horizontal spatial frequencies"
group.long 0xe324++0x3
line.long 0x00 "0xe324"
hexmask.long.byte 0x00 0.--7. 1. " Thresh 4h  ,Noise threshold for low horizontal spatial frequencies"
group.long 0xe328++0x3
line.long 0x00 "0xe328"
hexmask.long.byte 0x00 0.--7. 1. " Thresh 1v  ,Noise threshold for high vertical spatial frequencies"
group.long 0xe32c++0x3
line.long 0x00 "0xe32c"
hexmask.long.byte 0x00 0.--7. 1. " Thresh 4v  ,Noise threshold for low vertical spatial frequencies"
group.long 0xe334++0x3
line.long 0x00 "0xe334"
hexmask.long.byte 0x00 0.--7. 1. " Thresh Short  ,Noise threshold adjustment for short exposure data"
group.long 0xe338++0x3
line.long 0x00 "0xe338"
hexmask.long.byte 0x00 0.--7. 1. " Thresh Long  ,Noise threshold adjustment for long exposure data"
group.long 0xe340++0x3
line.long 0x00 "0xe340"
hexmask.long.byte 0x00 0.--7. 1. " Strength 1  ,Noise reduction effect for high spatial frequencies"
group.long 0xe348++0x3
line.long 0x00 "0xe348"
hexmask.long.byte 0x00 0.--7. 1. " Strength 4  ,Noise reduction effect for low spatial frequencies"
group.long 0x0++0x25
TREE.END
TREE "Backend LUT"
group.long 0xe350++0x3
line.long 0x00 "0xe350"
textline "                 "
bitfld.long 0x00 0. " Enable 0  , Backend lookup0 enable: 0=off 1=on  "
bitfld.long 0x00 1. " Enable 1  , Backend lookup1 enable: 0=off 1=on  "
bitfld.long 0x00 2. " Enable DL  , Backend lookup1 enable: 0=off 1=on  "
group.long 0xe354++0x3
line.long 0x00 "0xe354"
hexmask.long.long 0x00 0.--24. 1. " Data Last 0  ,LUT0 last node"
group.long 0xe358++0x3
line.long 0x00 "0xe358"
hexmask.long.long 0x00 0.--24. 1. " Data Last 1  ,LUT0 last node"
group.long 0xe35c++0x3
line.long 0x00 "0xe35c"
hexmask.long.long 0x00 0.--21. 1. " Alpha  ,Back end alpha 9.12 fix point"
group.long 0xe360++0x3
line.long 0x00 "0xe360"
hexmask.long.long 0x00 0.--23. 1. " Black level in DL  ,Backend DL table input black level"
group.long 0xe364++0x3
line.long 0x00 "0xe364"
hexmask.long.long 0x00 0.--23. 1. " Black level out DL  ,Backend DL table output black level"
TREE.END
TREE "Noise Profile"
group.long 0xfd00++0x80
line.quad 0x00 "0xfd00"
hexmask.long.byte 0x0 0.--7. 1. " Noise Profile LUT Weight lut[0] , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.long.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.long.byte 0x4 8.--15. 1. "  [5]  , "
hexmask.long.byte 0x4 16.--23. 1. "  [6]  , "
hexmask.long.byte 0x4 24.--31. 1. "  [7]  , "
hexmask.long.byte 0x8 0.--7. 1. "  [8]  , "
hexmask.long.byte 0x8 8.--15. 1. "  [9]  , "
hexmask.long.byte 0x8 16.--23. 1. "  [10] , "
hexmask.long.byte 0x8 24.--31. 1. "  [11] , "
hexmask.long.byte 0xc 0.--7. 1. "  [12] , "
hexmask.long.byte 0xc 8.--15. 1. "  [13] , "
hexmask.long.byte 0xc 16.--23. 1. "  [14] , "
hexmask.long.byte 0xc 24.--31. 1. "  [15] , "
hexmask.long.byte 0x10 0.--7. 1. "  [16] , "
hexmask.long.byte 0x10 8.--15. 1. "  [17] , "
hexmask.long.byte 0x10 16.--23. 1. "  [18] , "
hexmask.long.byte 0x10 24.--31. 1. "  [19] , "
hexmask.long.byte 0x14 0.--7. 1. "  [20] , "
hexmask.long.byte 0x14 8.--15. 1. "  [21] , "
hexmask.long.byte 0x14 16.--23. 1. "  [22] , "
hexmask.long.byte 0x14 24.--31. 1. "  [23] , "
hexmask.long.byte 0x18 0.--7. 1. "  [24] , "
hexmask.long.byte 0x18 8.--15. 1. "  [25] , "
hexmask.long.byte 0x18 16.--23. 1. "  [26] , "
hexmask.long.byte 0x18 24.--31. 1. "  [27] , "
hexmask.long.byte 0x1c 0.--7. 1. "  [28] , "
hexmask.long.byte 0x1c 8.--15. 1. "  [29] , "
hexmask.long.byte 0x1c 16.--23. 1. "  [30] , "
hexmask.long.byte 0x1c 24.--31. 1. "  [31] , "
hexmask.long.byte 0x20 0.--7. 1. "  [32] , "
hexmask.long.byte 0x20 8.--15. 1. "  [33] , "
hexmask.long.byte 0x20 16.--23. 1. "  [34] , "
hexmask.long.byte 0x20 24.--31. 1. "  [35] , "
hexmask.long.byte 0x24 0.--7. 1. "  [36] , "
hexmask.long.byte 0x24 8.--15. 1. "  [37] , "
hexmask.long.byte 0x24 16.--23. 1. "  [38] , "
hexmask.long.byte 0x24 24.--31. 1. "  [39] , "
hexmask.long.byte 0x28 0.--7. 1. "  [40] , "
hexmask.long.byte 0x28 8.--15. 1. "  [41] , "
hexmask.long.byte 0x28 16.--23. 1. "  [42] , "
hexmask.long.byte 0x28 24.--31. 1. "  [43] , "
hexmask.long.byte 0x2c 0.--7. 1. "  [44] , "
hexmask.long.byte 0x2c 8.--15. 1. "  [45] , "
hexmask.long.byte 0x2c 16.--23. 1. "  [46] , "
hexmask.long.byte 0x2c 24.--31. 1. "  [47] , "
hexmask.long.byte 0x30 0.--7. 1. "  [48] , "
hexmask.long.byte 0x30 8.--15. 1. "  [49] , "
hexmask.long.byte 0x30 16.--23. 1. "  [50] , "
hexmask.long.byte 0x30 24.--31. 1. "  [51] , "
hexmask.long.byte 0x34 0.--7. 1. "  [52] , "
hexmask.long.byte 0x34 8.--15. 1. "  [53] , "
hexmask.long.byte 0x34 16.--23. 1. "  [54] , "
hexmask.long.byte 0x34 24.--31. 1. "  [55] , "
hexmask.long.byte 0x38 0.--7. 1. "  [56] , "
hexmask.long.byte 0x38 8.--15. 1. "  [57] , "
hexmask.long.byte 0x38 16.--23. 1. "  [58] , "
hexmask.long.byte 0x38 24.--31. 1. "  [59] , "
hexmask.long.byte 0x3c 0.--7. 1. "  [60] , "
hexmask.long.byte 0x3c 8.--15. 1. "  [61] , "
hexmask.long.byte 0x3c 16.--23. 1. "  [62] , "
hexmask.long.byte 0x3c 24.--31. 1. "  [63] , "
hexmask.long.byte 0x40 0.--7. 1. "  [64] , "
hexmask.long.byte 0x40 8.--15. 1. "  [65] , "
hexmask.long.byte 0x40 16.--23. 1. "  [66] , "
hexmask.long.byte 0x40 24.--31. 1. "  [67] , "
hexmask.long.byte 0x44 0.--7. 1. "  [68] , "
hexmask.long.byte 0x44 8.--15. 1. "  [69] , "
hexmask.long.byte 0x44 16.--23. 1. "  [70] , "
hexmask.long.byte 0x44 24.--31. 1. "  [71] , "
hexmask.long.byte 0x48 0.--7. 1. "  [72] , "
hexmask.long.byte 0x48 8.--15. 1. "  [73] , "
hexmask.long.byte 0x48 16.--23. 1. "  [74] , "
hexmask.long.byte 0x48 24.--31. 1. "  [75] , "
hexmask.long.byte 0x4c 0.--7. 1. "  [76] , "
hexmask.long.byte 0x4c 8.--15. 1. "  [77] , "
hexmask.long.byte 0x4c 16.--23. 1. "  [78] , "
hexmask.long.byte 0x4c 24.--31. 1. "  [79] , "
hexmask.long.byte 0x50 0.--7. 1. "  [80] , "
hexmask.long.byte 0x50 8.--15. 1. "  [81] , "
hexmask.long.byte 0x50 16.--23. 1. "  [82] , "
hexmask.long.byte 0x50 24.--31. 1. "  [83] , "
hexmask.long.byte 0x54 0.--7. 1. "  [84] , "
hexmask.long.byte 0x54 8.--15. 1. "  [85] , "
hexmask.long.byte 0x54 16.--23. 1. "  [86] , "
hexmask.long.byte 0x54 24.--31. 1. "  [87] , "
hexmask.long.byte 0x58 0.--7. 1. "  [88] , "
hexmask.long.byte 0x58 8.--15. 1. "  [89] , "
hexmask.long.byte 0x58 16.--23. 1. "  [90] , "
hexmask.long.byte 0x58 24.--31. 1. "  [91] , "
hexmask.long.byte 0x5c 0.--7. 1. "  [92] , "
hexmask.long.byte 0x5c 8.--15. 1. "  [93] , "
hexmask.long.byte 0x5c 16.--23. 1. "  [94] , "
hexmask.long.byte 0x5c 24.--31. 1. "  [95] , "
hexmask.long.byte 0x60 0.--7. 1. "  [96] , "
hexmask.long.byte 0x60 8.--15. 1. "  [97] , "
hexmask.long.byte 0x60 16.--23. 1. "  [98] , "
hexmask.long.byte 0x60 24.--31. 1. "  [99] , "
hexmask.long.byte 0x64 0.--7. 1. "  [100] , "
hexmask.long.byte 0x64 8.--15. 1. "  [101] , "
hexmask.long.byte 0x64 16.--23. 1. "  [102] , "
hexmask.long.byte 0x64 24.--31. 1. "  [103] , "
hexmask.long.byte 0x68 0.--7. 1. "  [104] , "
hexmask.long.byte 0x68 8.--15. 1. "  [105] , "
hexmask.long.byte 0x68 16.--23. 1. "  [106] , "
hexmask.long.byte 0x68 24.--31. 1. "  [107] , "
hexmask.long.byte 0x6c 0.--7. 1. "  [108] , "
hexmask.long.byte 0x6c 8.--15. 1. "  [109] , "
hexmask.long.byte 0x6c 16.--23. 1. "  [110] , "
hexmask.long.byte 0x6c 24.--31. 1. "  [111] , "
hexmask.long.byte 0x70 0.--7. 1. "  [112] , "
hexmask.long.byte 0x70 8.--15. 1. "  [113] , "
hexmask.long.byte 0x70 16.--23. 1. "  [114] , "
hexmask.long.byte 0x70 24.--31. 1. "  [115] , "
hexmask.long.byte 0x74 0.--7. 1. "  [116] , "
hexmask.long.byte 0x74 8.--15. 1. "  [117] , "
hexmask.long.byte 0x74 16.--23. 1. "  [118] , "
hexmask.long.byte 0x74 24.--31. 1. "  [119] , "
hexmask.long.byte 0x78 0.--7. 1. "  [120] , "
hexmask.long.byte 0x78 8.--15. 1. "  [121] , "
hexmask.long.byte 0x78 16.--23. 1. "  [122] , "
hexmask.long.byte 0x78 24.--31. 1. "  [123] , "
hexmask.long.byte 0x7c 0.--7. 1. "  [124] , "
hexmask.long.byte 0x7c 8.--15. 1. "  [125] , "
hexmask.long.byte 0x7c 16.--23. 1. "  [126] , "
hexmask.long.byte 0x7c 24.--31. 1. "  [127] , "
group.long 0xe370++0x3
line.long 0x00 "0xe370"
hexmask.long.word 0x00 0.--15. 1. " Exp Thresh  ,Threshold for determining long/short exposure data"
group.long 0xe374++0x3
line.long 0x00 "0xe374"
hexmask.long.byte 0x00 0.--7. 1. " Short Ratio  ,Multiplier applied to short exposure data for noise profile calculation"
group.long 0xe378++0x3
line.long 0x00 "0xe378"
hexmask.long.byte 0x00 0.--7. 1. " Long Ratio  ,Multiplier applied to long exposure data for noise profile calculation"
group.long 0xe37c++0x3
line.long 0x00 "0xe37c"
hexmask.long.byte 0x00 0.--6. 1. " NP off  ,Noise profile black level offset"
textline "                 "
bitfld.long 0x00 7. " NP off reflect  , Defines how values below black level are obtained.           0: Repeat the first table entry.           1: Reflect the noise profile curve below black level.  "
TREE.END
TREE "White Balance"
group.long 0xe380++0x3
line.long 0x00 "0xe380"
hexmask.long.word 0x00 0.--11. 1. " Gain 00  ,Multiplier for color channel 00 (R)"
group.long 0xe384++0x3
line.long 0x00 "0xe384"
hexmask.long.word 0x00 0.--11. 1. " Gain 01  ,Multiplier for color channel 01 (Gr)"
group.long 0xe388++0x3
line.long 0x00 "0xe388"
hexmask.long.word 0x00 0.--11. 1. " Gain 10  ,Multiplier for color channel 10 (Gb)"
group.long 0xe38c++0x3
line.long 0x00 "0xe38c"
hexmask.long.word 0x00 0.--11. 1. " Gain 11  ,Multiplier for color channel 11 (B)"
TREE.END
TREE "Offset"
group.long 0xe390++0x3
line.long 0x00 "0xe390"
hexmask.long.long 0x00 0.--23. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xe394++0x3
line.long 0x00 "0xe394"
hexmask.long.long 0x00 0.--23. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xe398++0x3
line.long 0x00 "0xe398"
hexmask.long.long 0x00 0.--23. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xe39c++0x3
line.long 0x00 "0xe39c"
hexmask.long.long 0x00 0.--23. 1. " Black 11  ,Black offset for color channel 11 (B)"
TREE.END
TREE "CA Correction"
group.long 0xe3a0++0x3
line.long 0x00 "0xe3a0"
textline "                 "
bitfld.long 0x00 0. " Enable  , CA correction enable: 0=off, 1=on  "
hexmask.long.byte 0x00 14.--15. 1. " Mesh Scale  ,Mesh scaling"
hexmask.long.byte 0x00 16.--22. 1. " Mesh width  ,Number of horizontal nodes minus 1"
hexmask.long.byte 0x00 24.--30. 1. " Mesh height  ,Number of vertical nodes minus 1"
group.long 0xe3a4++0x3
line.long 0x00 "0xe3a4"
hexmask.long.word 0x00 0.--12. 1. " Line offset  ,Offset to next line of mesh data"
hexmask.long.word 0x00 16.--28. 1. " Plane offset  ,Offset to next plane of mesh data"
group.long 0xe3a8++0x3
line.long 0x00 "0xe3a8"
textline "                 "
bitfld.long 0x00 0. " Mesh reload  , 0-1 triggers cache reload  "
TREE.END
TREE "Radial Shading"
group.long 0xe3b0++0x3
line.long 0x00 "0xe3b0"
textline "                 "
bitfld.long 0x00 0. " Enable  , Lens shading correction enable: 0=off, 1=on  "
group.long 0xe3b8++0x3
line.long 0x00 "0xe3b8"
hexmask.long.word 0x00 0.--15. 1. " centerR x  ,Center x coordinate of the red shading map"
hexmask.long.word 0x00 16.--31. 1. " centerR y  ,Center y coordinate of the red shading map"
group.long 0xe3bc++0x3
line.long 0x00 "0xe3bc"
hexmask.long.word 0x00 0.--15. 1. " centerG x  ,Center x coordinate of the green shading map"
hexmask.long.word 0x00 16.--31. 1. " centerG y  ,Center y coordinate of the green shading map"
group.long 0xe3c0++0x3
line.long 0x00 "0xe3c0"
hexmask.long.word 0x00 0.--15. 1. " centerB x  ,Center x coordinate of the blue shading map"
hexmask.long.word 0x00 16.--31. 1. " centerB y  ,Center y coordinate of the blue shading map"
group.long 0xe3c4++0x3
line.long 0x00 "0xe3c4"
hexmask.long.word 0x00 0.--15. 1. " centerIr x  ,Center x coordinate of the IR shading map"
hexmask.long.word 0x00 16.--31. 1. " centerIr y  ,Center y coordinate of the IR shading map"
group.long 0xe3c8++0x3
line.long 0x00 "0xe3c8"
hexmask.long.word 0x00 0.--15. 1. " off center multRx  ,Normalizing X factor which scales the Red radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
hexmask.long.word 0x00 16.--31. 1. " off center multRy  ,Normalizing Y factor which scales the Red radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xe3cc++0x3
line.long 0x00 "0xe3cc"
hexmask.long.word 0x00 0.--15. 1. " off center multGx  ,Normalizing X factor which scales the green radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
hexmask.long.word 0x00 16.--31. 1. " off center multGy  ,Normalizing Y factor which scales the green radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xe3d0++0x3
line.long 0x00 "0xe3d0"
hexmask.long.word 0x00 0.--15. 1. " off center multBx  ,Normalizing X factor which scales the blue radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
hexmask.long.word 0x00 16.--31. 1. " off center multBy  ,Normalizing Y factor which scales the blue radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xe3d4++0x3
line.long 0x00 "0xe3d4"
hexmask.long.word 0x00 0.--15. 1. " off center multIRx  ,Normalizing X factor which scales the Ir radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
hexmask.long.word 0x00 16.--31. 1. " off center multIRy  ,Normalizing Y factor which scales the Ir radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
TREE.END
TREE "Mesh Shading"
group.long 0xe3e0++0x3
line.long 0x00 "0xe3e0"
textline "                 "
bitfld.long 0x00 0. " Enable  , Lens shading correction enable: 0=off, 1=on  "
bitfld.long 0x00 1. " Mesh show  , Lens shading correction debug: 0=off, 1=on (show mesh data)  "
hexmask.long.byte 0x00 2.--4. 1. " Mesh scale  ,Selects the precision and maximal gain range of mesh shading correction         Gain range:    00->0..2; 01->0..4; 02->0..8; 03->0..16; 04->1..2; 05->1..3; 06-> 1..5; 07->1..9(float)"
hexmask.long.byte 0x00 8.--9. 1. " Mesh page R  ,Selects memory page for red pixels correction.  See ISP guide for further details"
hexmask.long.byte 0x00 10.--11. 1. " Mesh page G  ,Selects memory page for green pixels correction.  See ISP guide for further details"
hexmask.long.byte 0x00 12.--13. 1. " Mesh page B  ,Selects memory page for blue pixels correction.  See ISP guide for further details"
hexmask.long.byte 0x00 14.--15. 1. " Mesh page Ir  ,Selects memory page for IR pixels correction.  See ISP guide for further details"
hexmask.long.byte 0x00 16.--21. 1. " Mesh width  ,Number of horizontal nodes minus 1"
hexmask.long.byte 0x00 24.--29. 1. " Mesh height  ,Number of vertical nodes minus 1"
group.long 0xe3e4++0x3
line.long 0x00 "0xe3e4"
textline "                 "
bitfld.long 0x00 0. " Mesh reload  , 0-1 triggers cache reload  "
group.long 0xe3f0++0x3
line.long 0x00 "0xe3f0"
hexmask.long.byte 0x00 0.--1. 1. " Mesh alpha mode  ,Sets alpha blending between mesh shading tables.         0 = no alpha blending;          1=2 banks (odd/even bytes)          2=4 banks (one per 8 bit lane in each dword)"
group.long 0xe3f4++0x3
line.long 0x00 "0xe3f4"
hexmask.long.byte 0x00 0.--2. 1. " Mesh alpha bank R  ,Bank selection for R blend: 0: 0+1; 1: 1+2; 2: 2:3; 3: 3+0; 4:0+2; 5: 1+3; 6,7: reserved"
hexmask.long.byte 0x00 8.--10. 1. " Mesh alpha bank G  ,Bank selection for G blend: 0: 0+1; 1: 1+2; 2: 2:3; 3: 3+0; 4:0+2; 5: 1+3; 6,7: reserved:"
hexmask.long.byte 0x00 16.--18. 1. " Mesh alpha bank B  ,Bank selection for B blend: 0: 0+1; 1: 1+2; 2: 2:3; 3: 3+0; 4:0+2; 5: 1+3; 6,7: reserved"
hexmask.long.byte 0x00 24.--26. 1. " Mesh alpha bank Ir  ,Bank selection for Ir blend: 0: 0+1; 1: 1+2; 2: 2:3; 3: 3+0; 4:0+2; 5: 1+3; 6,7: reserved"
group.long 0xe3f8++0x3
line.long 0x00 "0xe3f8"
hexmask.long.byte 0x00 0.--7. 1. " Mesh alpha R  ,Alpha blend coeff for R"
hexmask.long.byte 0x00 8.--15. 1. " Mesh alpha G  ,Alpha blend coeff for G"
hexmask.long.byte 0x00 16.--23. 1. " Mesh alpha B  ,Alpha blend coeff for B"
hexmask.long.byte 0x00 24.--31. 1. " Mesh alpha Ir  ,Alpha blend coeff for IR"
group.long 0xe3fc++0x3
line.long 0x00 "0xe3fc"
hexmask.long.word 0x00 0.--15. 1. " Mesh strength  ,Mesh strength in 4.12 format, e.g. 0 - no correction, 4096 - correction to match mesh data. Can be used to reduce shading correction based on AE."
TREE.END
TREE "Digital Gain Iridix"
group.long 0xe368++0x3
line.long 0x00 "0xe368"
hexmask.long.word 0x00 0.--12. 1. " Gain  ,Gain applied to data in 5.8 format"
group.long 0xe36c++0x3
line.long 0x00 "0xe36c"
hexmask.long.long 0x00 0.--23. 1. " Offset  ,Data black level"
TREE.END
TREE "Iridix"
group.long 0xe400++0x3
line.long 0x00 "0xe400"
textline "                 "
bitfld.long 0x00 0. " iridix_on  , Iridix enable: 0=off 1=on  "
bitfld.long 0x00 16. " gtm_select  ,   "
group.long 0xe408++0x3
line.long 0x00 "0xe408"
hexmask.long.byte 0x00 0.--3. 1. " variance_space  ,Sets the degree of spatial sensitivity of the algorithm(Irdx7F)"
hexmask.long.byte 0x00 4.--7. 1. " variance_intensity  ,Sets the degree of luminance sensitivity of the algorithm(Irdx7F)"
hexmask.long.byte 0x00 8.--15. 1. " slope_max  ,Restricts the maximum slope (gain) which can be generated by the adaptive algorithm"
hexmask.long.byte 0x00 16.--23. 1. " slope_min  ,Restricts the minimum slope (gain) which can be generated by the adaptive algorithm"
group.long 0xe410++0x3
line.long 0x00 "0xe410"
hexmask.long.long 0x00 0.--23. 1. " black_level  ,Iridix black level. Values below this will not be affected by Iridix."
group.long 0xe414++0x3
line.long 0x00 "0xe414"
hexmask.long.long 0x00 0.--23. 1. " white_level  ,Iridix white level. Values above this will not be affected by Iridix."
group.long 0xe41c++0x3
line.long 0x00 "0xe41c"
hexmask.long.word 0x00 0.--11. 1. " collection_correction  ,"
group.long 0xe420++0x3
line.long 0x00 "0xe420"
hexmask.long.byte 0x00 0.--1. 1. " fwd_percept_control  ,Iridix gamma processing select: 0=pass through 1=gamma_dl 2=sqrt 3=gamma_lut."
hexmask.long.byte 0x00 2.--3. 1. " rev_percept_control  ,Iridix gamma processing select: 0=pass through 1=gamma_dl 2=sqrt 3=gamma_lut."
hexmask.long.word 0x00 16.--25. 1. " strength_inroi  ,"
group.long 0xe424++0x3
line.long 0x00 "0xe424"
hexmask.long.word 0x00 0.--9. 1. " strength_outroi  ,"
hexmask.long.word 0x00 16.--31. 1. " roi_hor_start  ,"
group.long 0xe428++0x3
line.long 0x00 "0xe428"
hexmask.long.word 0x00 0.--15. 1. " roi_hor_end  ,"
hexmask.long.word 0x00 16.--31. 1. " roi_ver_start  ,"
group.long 0xe42c++0x3
line.long 0x00 "0xe42c"
hexmask.long.word 0x00 0.--15. 1. " roi_ver_end  ,"
group.long 0xe430++0x3
line.long 0x00 "0xe430"
textline "                 "
bitfld.long 0x00 0. " filter_mux  ,   "
hexmask.long.byte 0x00 8.--11. 1. " svariance  ,"
hexmask.long.byte 0x00 16.--23. 1. " bright_pr  ,"
hexmask.long.byte 0x00 24.--31. 1. " contrast  ,"
group.long 0xe434++0x3
line.long 0x00 "0xe434"
hexmask.long.word 0x00 0.--15. 1. " dark_enh  ,"
group.long 0xe43c++0x3
line.long 0x00 "0xe43c"
hexmask.long.long 0x00 0.--23. 1. " WB offset  ,"
group.long 0xe440++0x3
line.long 0x00 "0xe440"
hexmask.long.word 0x00 0.--11. 1. " Gain R  ,"
group.long 0xe444++0x3
line.long 0x00 "0xe444"
hexmask.long.word 0x00 0.--11. 1. " Gain Gr  ,"
group.long 0xe448++0x3
line.long 0x00 "0xe448"
hexmask.long.word 0x00 0.--11. 1. " Gain Gb  ,"
group.long 0xe44c++0x3
line.long 0x00 "0xe44c"
hexmask.long.word 0x00 0.--11. 1. " Gain B  ,"
group.long 0xe450++0x3
line.long 0x00 "0xe450"
hexmask.long.long 0x00 0.--17. 1. " Fwd Alpha  ,"
group.long 0xe454++0x3
line.long 0x00 "0xe454"
hexmask.long.long 0x00 0.--17. 1. " Rev Alpha  ,"
group.long 0x0++0x104
TREE.END
TREE "Demosaic"
group.long 0xe480++0x3
line.long 0x00 "0xe480"
hexmask.long.byte 0x00 0.--7. 1. " VH Slope  ,Slope of vertical/horizontal blending threshold in 4.4 logarithmic format"
group.long 0xe484++0x3
line.long 0x00 "0xe484"
hexmask.long.byte 0x00 0.--7. 1. " AA Slope  ,Slope of angular blending threshold in 4.4 logarithmic format"
group.long 0xe488++0x3
line.long 0x00 "0xe488"
hexmask.long.byte 0x00 0.--7. 1. " VA Slope  ,Slope of VH-AA (VA) blending threshold in 4.4 logarithmic format"
group.long 0xe48c++0x3
line.long 0x00 "0xe48c"
hexmask.long.byte 0x00 0.--7. 1. " UU Slope  ,Slope of undefined blending threshold in 4.4 logarithmic format"
group.long 0xe490++0x3
line.long 0x00 "0xe490"
hexmask.long.byte 0x00 0.--7. 1. " Sat Slope  ,Slope of saturation blending threshold in linear format 2.6"
group.long 0xe494++0x3
line.long 0x00 "0xe494"
hexmask.long.word 0x00 0.--13. 1. " VH Thresh  ,Threshold for the range of vertical/horizontal blending"
group.long 0xe498++0x3
line.long 0x00 "0xe498"
hexmask.long.word 0x00 0.--13. 1. " AA Thresh  ,Threshold for the range of angular blending"
group.long 0xe49c++0x3
line.long 0x00 "0xe49c"
hexmask.long.word 0x00 0.--13. 1. " VA Thresh  ,Threshold for the range of VA blending"
group.long 0xe4a0++0x3
line.long 0x00 "0xe4a0"
hexmask.long.word 0x00 0.--13. 1. " UU Thresh  ,Threshold for the range of undefined blending"
group.long 0xe4a4++0x3
line.long 0x00 "0xe4a4"
hexmask.long.word 0x00 0.--13. 1. " Sat Thresh  ,Threshold for the range of saturation blending  in signed 2.9 format"
group.long 0xe4a8++0x3
line.long 0x00 "0xe4a8"
hexmask.long.word 0x00 0.--13. 1. " VH Offset  ,Offset for vertical/horizontal blending threshold"
group.long 0xe4ac++0x3
line.long 0x00 "0xe4ac"
hexmask.long.word 0x00 0.--13. 1. " AA Offset  ,Offset for angular blending threshold"
group.long 0xe4b0++0x3
line.long 0x00 "0xe4b0"
hexmask.long.word 0x00 0.--13. 1. " VA Offset  ,Offset for VA blending threshold"
group.long 0xe4b4++0x3
line.long 0x00 "0xe4b4"
hexmask.long.word 0x00 0.--13. 1. " UU Offset  ,Offset for undefined blending threshold"
group.long 0xe4b8++0x3
line.long 0x00 "0xe4b8"
hexmask.long.word 0x00 0.--13. 1. " Sat Offset  ,Offset for saturation blending threshold in signed 2.9 format"
group.long 0xe4bc++0x3
line.long 0x00 "0xe4bc"
hexmask.long.byte 0x00 0.--7. 1. " sharp_alt_d  ,Directional sharp mask strength in signed 4.4 format"
group.long 0xe4c0++0x3
line.long 0x00 "0xe4c0"
hexmask.long.byte 0x00 0.--7. 1. " sharp_alt_ud  ,Non-directional sharp mask strength in signed 4.4 format"
group.long 0xe4c4++0x3
line.long 0x00 "0xe4c4"
hexmask.long.word 0x00 0.--13. 1. " lum_thresh  ,Luminance threshold for directional sharpening"
group.long 0xe4c8++0x3
line.long 0x00 "0xe4c8"
hexmask.long.byte 0x00 0.--7. 1. " np_offset  ,Noise profile offset in logarithmic 4.4 format"
group.long 0xe4cc++0x3
line.long 0x00 "0xe4cc"
hexmask.long.byte 0x00 0.--7. 1. " Dmsc config  ,Debug output select. Set to 0x00 for normal operation."
group.long 0xe4d0++0x3
line.long 0x00 "0xe4d0"
hexmask.long.word 0x00 0.--13. 1. " AC Thresh  ,Threshold for the range of AC blending in signed 2.9 format"
group.long 0xe4d4++0x3
line.long 0x00 "0xe4d4"
hexmask.long.byte 0x00 0.--7. 1. " AC Slope  ,Slope of AC blending threshold in linear format 2.6"
group.long 0xe4d8++0x3
line.long 0x00 "0xe4d8"
hexmask.long.word 0x00 0.--13. 1. " AC Offset  ,Offset for AC blending threshold in signed 2.9 format"
group.long 0xe4dc++0x3
line.long 0x00 "0xe4dc"
hexmask.long.byte 0x00 0.--7. 1. " FC Slope  ,Slope (strength) of false color correction"
group.long 0xe4e0++0x3
line.long 0x00 "0xe4e0"
hexmask.long.byte 0x00 0.--7. 1. " FC Alias Slope  ,Slope (strength) of false colour correction after blending with saturation value in 2.6 unsigned format"
group.long 0xe4e4++0x3
line.long 0x00 "0xe4e4"
hexmask.long.byte 0x00 0.--7. 1. " FC Alias Thresh  ,Threshold of false colour correction after blending with saturation valuet in in 0.8 unsigned format"
group.long 0xfd80++0x80
line.quad 0x00 "0xfd80"
hexmask.long.byte 0x0 0.--7. 1. " Noise Profile Demosaic LUT Weight lut[0] , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.long.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.long.byte 0x4 8.--15. 1. "  [5]  , "
hexmask.long.byte 0x4 16.--23. 1. "  [6]  , "
hexmask.long.byte 0x4 24.--31. 1. "  [7]  , "
hexmask.long.byte 0x8 0.--7. 1. "  [8]  , "
hexmask.long.byte 0x8 8.--15. 1. "  [9]  , "
hexmask.long.byte 0x8 16.--23. 1. "  [10] , "
hexmask.long.byte 0x8 24.--31. 1. "  [11] , "
hexmask.long.byte 0xc 0.--7. 1. "  [12] , "
hexmask.long.byte 0xc 8.--15. 1. "  [13] , "
hexmask.long.byte 0xc 16.--23. 1. "  [14] , "
hexmask.long.byte 0xc 24.--31. 1. "  [15] , "
hexmask.long.byte 0x10 0.--7. 1. "  [16] , "
hexmask.long.byte 0x10 8.--15. 1. "  [17] , "
hexmask.long.byte 0x10 16.--23. 1. "  [18] , "
hexmask.long.byte 0x10 24.--31. 1. "  [19] , "
hexmask.long.byte 0x14 0.--7. 1. "  [20] , "
hexmask.long.byte 0x14 8.--15. 1. "  [21] , "
hexmask.long.byte 0x14 16.--23. 1. "  [22] , "
hexmask.long.byte 0x14 24.--31. 1. "  [23] , "
hexmask.long.byte 0x18 0.--7. 1. "  [24] , "
hexmask.long.byte 0x18 8.--15. 1. "  [25] , "
hexmask.long.byte 0x18 16.--23. 1. "  [26] , "
hexmask.long.byte 0x18 24.--31. 1. "  [27] , "
hexmask.long.byte 0x1c 0.--7. 1. "  [28] , "
hexmask.long.byte 0x1c 8.--15. 1. "  [29] , "
hexmask.long.byte 0x1c 16.--23. 1. "  [30] , "
hexmask.long.byte 0x1c 24.--31. 1. "  [31] , "
hexmask.long.byte 0x20 0.--7. 1. "  [32] , "
hexmask.long.byte 0x20 8.--15. 1. "  [33] , "
hexmask.long.byte 0x20 16.--23. 1. "  [34] , "
hexmask.long.byte 0x20 24.--31. 1. "  [35] , "
hexmask.long.byte 0x24 0.--7. 1. "  [36] , "
hexmask.long.byte 0x24 8.--15. 1. "  [37] , "
hexmask.long.byte 0x24 16.--23. 1. "  [38] , "
hexmask.long.byte 0x24 24.--31. 1. "  [39] , "
hexmask.long.byte 0x28 0.--7. 1. "  [40] , "
hexmask.long.byte 0x28 8.--15. 1. "  [41] , "
hexmask.long.byte 0x28 16.--23. 1. "  [42] , "
hexmask.long.byte 0x28 24.--31. 1. "  [43] , "
hexmask.long.byte 0x2c 0.--7. 1. "  [44] , "
hexmask.long.byte 0x2c 8.--15. 1. "  [45] , "
hexmask.long.byte 0x2c 16.--23. 1. "  [46] , "
hexmask.long.byte 0x2c 24.--31. 1. "  [47] , "
hexmask.long.byte 0x30 0.--7. 1. "  [48] , "
hexmask.long.byte 0x30 8.--15. 1. "  [49] , "
hexmask.long.byte 0x30 16.--23. 1. "  [50] , "
hexmask.long.byte 0x30 24.--31. 1. "  [51] , "
hexmask.long.byte 0x34 0.--7. 1. "  [52] , "
hexmask.long.byte 0x34 8.--15. 1. "  [53] , "
hexmask.long.byte 0x34 16.--23. 1. "  [54] , "
hexmask.long.byte 0x34 24.--31. 1. "  [55] , "
hexmask.long.byte 0x38 0.--7. 1. "  [56] , "
hexmask.long.byte 0x38 8.--15. 1. "  [57] , "
hexmask.long.byte 0x38 16.--23. 1. "  [58] , "
hexmask.long.byte 0x38 24.--31. 1. "  [59] , "
hexmask.long.byte 0x3c 0.--7. 1. "  [60] , "
hexmask.long.byte 0x3c 8.--15. 1. "  [61] , "
hexmask.long.byte 0x3c 16.--23. 1. "  [62] , "
hexmask.long.byte 0x3c 24.--31. 1. "  [63] , "
hexmask.long.byte 0x40 0.--7. 1. "  [64] , "
hexmask.long.byte 0x40 8.--15. 1. "  [65] , "
hexmask.long.byte 0x40 16.--23. 1. "  [66] , "
hexmask.long.byte 0x40 24.--31. 1. "  [67] , "
hexmask.long.byte 0x44 0.--7. 1. "  [68] , "
hexmask.long.byte 0x44 8.--15. 1. "  [69] , "
hexmask.long.byte 0x44 16.--23. 1. "  [70] , "
hexmask.long.byte 0x44 24.--31. 1. "  [71] , "
hexmask.long.byte 0x48 0.--7. 1. "  [72] , "
hexmask.long.byte 0x48 8.--15. 1. "  [73] , "
hexmask.long.byte 0x48 16.--23. 1. "  [74] , "
hexmask.long.byte 0x48 24.--31. 1. "  [75] , "
hexmask.long.byte 0x4c 0.--7. 1. "  [76] , "
hexmask.long.byte 0x4c 8.--15. 1. "  [77] , "
hexmask.long.byte 0x4c 16.--23. 1. "  [78] , "
hexmask.long.byte 0x4c 24.--31. 1. "  [79] , "
hexmask.long.byte 0x50 0.--7. 1. "  [80] , "
hexmask.long.byte 0x50 8.--15. 1. "  [81] , "
hexmask.long.byte 0x50 16.--23. 1. "  [82] , "
hexmask.long.byte 0x50 24.--31. 1. "  [83] , "
hexmask.long.byte 0x54 0.--7. 1. "  [84] , "
hexmask.long.byte 0x54 8.--15. 1. "  [85] , "
hexmask.long.byte 0x54 16.--23. 1. "  [86] , "
hexmask.long.byte 0x54 24.--31. 1. "  [87] , "
hexmask.long.byte 0x58 0.--7. 1. "  [88] , "
hexmask.long.byte 0x58 8.--15. 1. "  [89] , "
hexmask.long.byte 0x58 16.--23. 1. "  [90] , "
hexmask.long.byte 0x58 24.--31. 1. "  [91] , "
hexmask.long.byte 0x5c 0.--7. 1. "  [92] , "
hexmask.long.byte 0x5c 8.--15. 1. "  [93] , "
hexmask.long.byte 0x5c 16.--23. 1. "  [94] , "
hexmask.long.byte 0x5c 24.--31. 1. "  [95] , "
hexmask.long.byte 0x60 0.--7. 1. "  [96] , "
hexmask.long.byte 0x60 8.--15. 1. "  [97] , "
hexmask.long.byte 0x60 16.--23. 1. "  [98] , "
hexmask.long.byte 0x60 24.--31. 1. "  [99] , "
hexmask.long.byte 0x64 0.--7. 1. "  [100] , "
hexmask.long.byte 0x64 8.--15. 1. "  [101] , "
hexmask.long.byte 0x64 16.--23. 1. "  [102] , "
hexmask.long.byte 0x64 24.--31. 1. "  [103] , "
hexmask.long.byte 0x68 0.--7. 1. "  [104] , "
hexmask.long.byte 0x68 8.--15. 1. "  [105] , "
hexmask.long.byte 0x68 16.--23. 1. "  [106] , "
hexmask.long.byte 0x68 24.--31. 1. "  [107] , "
hexmask.long.byte 0x6c 0.--7. 1. "  [108] , "
hexmask.long.byte 0x6c 8.--15. 1. "  [109] , "
hexmask.long.byte 0x6c 16.--23. 1. "  [110] , "
hexmask.long.byte 0x6c 24.--31. 1. "  [111] , "
hexmask.long.byte 0x70 0.--7. 1. "  [112] , "
hexmask.long.byte 0x70 8.--15. 1. "  [113] , "
hexmask.long.byte 0x70 16.--23. 1. "  [114] , "
hexmask.long.byte 0x70 24.--31. 1. "  [115] , "
hexmask.long.byte 0x74 0.--7. 1. "  [116] , "
hexmask.long.byte 0x74 8.--15. 1. "  [117] , "
hexmask.long.byte 0x74 16.--23. 1. "  [118] , "
hexmask.long.byte 0x74 24.--31. 1. "  [119] , "
hexmask.long.byte 0x78 0.--7. 1. "  [120] , "
hexmask.long.byte 0x78 8.--15. 1. "  [121] , "
hexmask.long.byte 0x78 16.--23. 1. "  [122] , "
hexmask.long.byte 0x78 24.--31. 1. "  [123] , "
hexmask.long.byte 0x7c 0.--7. 1. "  [124] , "
hexmask.long.byte 0x7c 8.--15. 1. "  [125] , "
hexmask.long.byte 0x7c 16.--23. 1. "  [126] , "
hexmask.long.byte 0x7c 24.--31. 1. "  [127] , "
group.long 0xe4ec++0x3
line.long 0x00 "0xe4ec"
hexmask.long.byte 0x00 0.--6. 1. " NP off  ,Noise profile black level offset"
textline "                 "
bitfld.long 0x00 7. " NP off reflect  , Defines how values below black level are obtained.           0: Repeat the first table entry.           1: Reflect the noise profile curve below black level.  "
group.long 0xe4f0++0x3
line.long 0x00 "0xe4f0"
hexmask.long.byte 0x00 0.--7. 1. " sharp_alt_ld  ,Sharpen strength for L_Ld in unsigned 4.4 format"
hexmask.long.byte 0x00 8.--15. 1. " sharp_alt_ldu  ,Sharpen strength for L_Ldu in unsigned 4.4 format"
hexmask.long.byte 0x00 16.--23. 1. " sharp_alt_lu  ,Sharpen strength for L_Lu in unsigned 4.4 format"
hexmask.long.byte 0x00 24.--31. 1. " sad_amp  ,Sad amplifier in unsigned 4.4 format"
group.long 0xe4f4++0x3
line.long 0x00 "0xe4f4"
hexmask.long.word 0x00 0.--14. 1. " min_d_strength  ,Min threshold for the directional L_L in signed 2's complement s.12 format"
hexmask.long.word 0x00 16.--30. 1. " min_ud_strength  ,Min threshold for the un-directional L_Lu in signed 2's complement s.12 format"
group.long 0xe4f8++0x3
line.long 0x00 "0xe4f8"
textline "                 "
bitfld.long 0x00 0. " sharpen_alg_select  , To select new sharp algorithm or not  "
TREE.END
TREE "Demosaic RGBIR"
group.long 0xe500++0x3
line.long 0x00 "0xe500"
hexmask.long.byte 0x00 0.--2. 1. " RGBIr config  ,Debug modes of the block."
group.long 0xe508++0x3
line.long 0x00 "0xe508"
hexmask.long.word 0x00 0.--13. 1. " Clip Level  ,Pixel values above this are deemed to be clipped"
group.long 0xe50c++0x3
line.long 0x00 "0xe50c"
hexmask.long.word 0x00 0.--13. 1. " Clip Debloom  ,Debloom level"
group.long 0xe510++0x3
line.long 0x00 "0xe510"
hexmask.long.word 0x00 0.--11. 1. " IR Correct Mat00  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
hexmask.long.word 0x00 16.--27. 1. " IR Correct Mat01  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
group.long 0xe514++0x3
line.long 0x00 "0xe514"
hexmask.long.word 0x00 0.--11. 1. " IR Correct Mat02  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
hexmask.long.word 0x00 16.--27. 1. " IR Correct Mat03  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
group.long 0xe518++0x3
line.long 0x00 "0xe518"
hexmask.long.word 0x00 0.--11. 1. " IR Correct Mat10  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
hexmask.long.word 0x00 16.--27. 1. " IR Correct Mat11  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
group.long 0xe51c++0x3
line.long 0x00 "0xe51c"
hexmask.long.word 0x00 0.--11. 1. " IR Correct Mat12  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
hexmask.long.word 0x00 16.--27. 1. " IR Correct Mat13  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
group.long 0xe520++0x3
line.long 0x00 "0xe520"
hexmask.long.word 0x00 0.--11. 1. " IR Correct Mat20  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
hexmask.long.word 0x00 16.--27. 1. " IR Correct Mat21  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
group.long 0xe524++0x3
line.long 0x00 "0xe524"
hexmask.long.word 0x00 0.--11. 1. " IR Correct Mat22  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
hexmask.long.word 0x00 16.--27. 1. " IR Correct Mat23  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
group.long 0xe528++0x3
line.long 0x00 "0xe528"
hexmask.long.word 0x00 0.--11. 1. " IR Correct Mat30  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
hexmask.long.word 0x00 16.--27. 1. " IR Correct Mat31  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
group.long 0xe52c++0x3
line.long 0x00 "0xe52c"
hexmask.long.word 0x00 0.--11. 1. " IR Correct Mat32  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
hexmask.long.word 0x00 16.--27. 1. " IR Correct Mat33  ,Coefficients for IR correction in format 2.10. Coefficients on main diagonal should be at least 256 (0.25)."
group.long 0xe530++0x3
line.long 0x00 "0xe530"
hexmask.long.word 0x00 0.--11. 1. " Gain R  ,White Balance gain for Red channel of output"
group.long 0xe534++0x3
line.long 0x00 "0xe534"
hexmask.long.word 0x00 0.--11. 1. " Gain B  ,White Balance gain for Blue channel of output"
group.long 0xe538++0x3
line.long 0x00 "0xe538"
hexmask.long.word 0x00 0.--11. 1. " Static Gain R  ,Static White Balance gain for Red channel of input"
group.long 0xe53c++0x3
line.long 0x00 "0xe53c"
hexmask.long.word 0x00 0.--11. 1. " Static Gain B  ,Static White Balance gain for Blue channel of input"
group.long 0xe540++0x3
line.long 0x00 "0xe540"
hexmask.long.word 0x00 0.--11. 1. " Static Gain I  ,Static White Balance gain for IR channel of input"
group.long 0xe544++0x3
line.long 0x00 "0xe544"
hexmask.long.word 0x00 0.--13. 1. " Interpolation Directionality  ,Sensitivity of directional interpolation to local gradient. Lower value means more sensitive. Increasing value will eventually result in bilinear demosaic"
group.long 0xe548++0x3
line.long 0x00 "0xe548"
hexmask.long.word 0x00 0.--13. 1. " FC Low  ,Value to start Colour Aliasing Alpha ramp"
group.long 0xe54c++0x3
line.long 0x00 "0xe54c"
hexmask.long.word 0x00 0.--11. 1. " FC Grad  ,Gradient of Colour Aliasing Alpha ramp"
group.long 0xe550++0x3
line.long 0x00 "0xe550"
hexmask.long.word 0x00 0.--11. 1. " Sharp Low  ,Sharpening strength in flat regions"
group.long 0xe554++0x3
line.long 0x00 "0xe554"
hexmask.long.word 0x00 0.--11. 1. " Sharp High  ,Sharpening strength in edge and detail regions"
group.long 0xe558++0x3
line.long 0x00 "0xe558"
hexmask.long.word 0x00 0.--13. 1. " Sharp Limit  ,Limit sharpening amount to prevent overshoot"
group.long 0xe55c++0x3
line.long 0x00 "0xe55c"
textline "                 "
bitfld.long 0x00 0. " Declip Mode  , Method of declipping in regions where R, G, and B are all clipped (0=Use local intensity to estimate., 1=Use constant value of 1.)  "
TREE.END
TREE "Demosaic RCCC"
group.long 0xe584++0x3
line.long 0x00 "0xe584"
hexmask.long.word 0x00 0.--11. 1. " Gain R  ,Gain of Red channel"
group.long 0xe588++0x3
line.long 0x00 "0xe588"
hexmask.long.word 0x00 0.--13. 1. " Interpolation directionality  ,"
group.long 0xe58c++0x3
line.long 0x00 "0xe58c"
hexmask.long.word 0x00 0.--11. 1. " C2 imbalance strength  ,"
group.long 0xe590++0x3
line.long 0x00 "0xe590"
hexmask.long.word 0x00 0.--11. 1. " C3 imbalance strength  ,"
group.long 0xe594++0x3
line.long 0x00 "0xe594"
hexmask.long.word 0x00 0.--11. 1. " Flatness value  ,"
group.long 0xe598++0x3
line.long 0x00 "0xe598"
hexmask.long.word 0x00 0.--11. 1. " Sharp high  ,"
group.long 0xe59c++0x3
line.long 0x00 "0xe59c"
hexmask.long.word 0x00 0.--11. 1. " Sharp low  ,"
group.long 0xe5a0++0x3
line.long 0x00 "0xe5a0"
hexmask.long.word 0x00 0.--13. 1. " Sharp limit  ,"
group.long 0xe5a4++0x3
line.long 0x00 "0xe5a4"
hexmask.long.word 0x00 0.--13. 1. " Wdr thresh low  ,"
group.long 0xe5a8++0x3
line.long 0x00 "0xe5a8"
hexmask.long.word 0x00 0.--13. 1. " Wdr thresh high  ,"
group.long 0xe5ac++0x3
line.long 0x00 "0xe5ac"
hexmask.long.word 0x00 0.--11. 1. " Max wdr gain rec  ,"
TREE.END
TREE "Output formatter"
group.long 0xe600++0x3
line.long 0x00 "0xe600"
textline "                 "
bitfld.long 0x00 0. " clip_rgb_bypass  , Bypass clip_rgb module  "
bitfld.long 0x00 1. " clip_luv_bypass  , Bypass clip_luv module  "
bitfld.long 0x00 2. " ir_ms_bypass  , Bypass ir_ms module  "
bitfld.long 0x00 3. " lut_rgb_bypass  , Bypass lut_rgb module  "
textline "                 "
bitfld.long 0x00 4. " lut_ir_bypass  , Bypass lut_ir module  "
bitfld.long 0x00 5. " lut_yuv_bypass  , Bypass lut_yuv module  "
bitfld.long 0x00 6. " lut_luv_bypass  , Bypass lut_luv module  "
bitfld.long 0x00 7. " rgb2rgb_bypass  , Bypass rgb2rgb module  "
textline "                 "
bitfld.long 0x00 8. " rgb2xyz_bypass  , Bypass rgb2xyz module  "
bitfld.long 0x00 9. " rgb2yuv_bypass  , Bypass rgb2yuv module  "
bitfld.long 0x00 10. " rgb2s_bypass  , Bypass rgb2s module  "
bitfld.long 0x00 11. " rgb2ab_bypass  , Bypass rgb2ab module  "
textline "                 "
bitfld.long 0x00 12. " ab2hs_bypass  , Bypass ab2hs module  "
bitfld.long 0x00 13. " xyz2luv_bypass  , Bypass xyz2luv module  "
bitfld.long 0x00 14. " rgb2yuv_sp_bypass  , Bypass rgb2yuv_sp module  "
bitfld.long 0x00 15. " lpf_ab_bypass  , Bypass lpf_ab module  "
textline "                 "
bitfld.long 0x00 16. " lpf_luv_bypass  , Bypass lpf_luv module  "
bitfld.long 0x00 17. " lpf_yuv_bypass  , Bypass lpf_yuv module  "
group.long 0xe608++0x3
line.long 0x00 "0xe608"
hexmask.long.byte 0x00 0.--1. 1. " sel_ir  ,Selector of video data channel for IR pipeline from four input video data channels.        0 - select the first channel       1 - select the second channel       2 - select the third channel       3 - select the fourth channel"
hexmask.long.byte 0x00 8.--10. 1. " ss_ir  ,Subsampling mode of IR channel video data.       ss_ir[2]   - if high then the subsampling mode is enabled.       ss_ir[1:0] - selects pixel for subsampling       0 - even row and even column pixels are selected       1 - even row and odd column pixels are selected       2 - odd row and even column pixels are selected       3 - odd row and odd column pixels are selected      The first pixel of frame is even row and even column pixel"
textline "                 "
bitfld.long 0x00 16. " sel_yuv_sp  , Select Standard or Special methods for rgb2yuv transformation.        0 - Standard mode, the rgb2yuv matrix is applied.        1 - Special mode, the other math formulas are supported. See rgb2yuv_sp_mode register description  "
hexmask.long.byte 0x00 24.--25. 1. " rgb2s_mode  ,Selects the method of calculation of S output video data from RGB data       0 - S=(max(R,G,B)-min(R,G,B))/2       1 - S=max(0,max(R,G,B)-max(min(R,G,B),rgb2s_clip))       2 - S=max(R,G,B)/max(min(R,G,B),rgb2s_clip)       3 - reserved"
group.long 0xe610++0x3
line.long 0x00 "0xe610"
hexmask.long.word 0x00 0.--13. 1. " rgb2s_clip  ,This value is used to calculate S output video data. See the rgb2s_mode register description."
group.long 0xe608++0x3
line.long 0x00 "0xe608"
hexmask.long.byte 0x00 28.--29. 1. " rgb2yuv_sp_mode  ,Selects the method of calculation of YUV output video data from RGB for Special mode.      For rgb2yuv_sp_mode[1]       0 - Y=(R+2G+B)/4       1 - Y=(R+G+B)/3      For rgb2yuv_sp_mode[0]       0 - U=(B-G+2048)/16, V=(R-G+2048)/16       1 - U=B/max(G,rgb2yuv_sp_clip), V=R/max(G,rgb2yuv_sp_clip)"
group.long 0xe610++0x3
line.long 0x00 "0xe610"
hexmask.long.word 0x00 16.--29. 1. " rgb2yuv_sp_clip  ,This value is used to calculate UV output video data in the Special YUV mode. See the rgb2yuv_sp_mode register description."
group.long 0xe614++0x3
line.long 0x00 "0xe614"
hexmask.long.word 0x00 0.--13. 1. " clip1_rgb  ,Maximum value for input video data of the first channel for RGB pipeline. Values above this are clipped."
hexmask.long.word 0x00 16.--29. 1. " clip2_rgb  ,Maximum value for input video data of the second channel for RGB pipeline. Values above this are clipped."
group.long 0xe618++0x3
line.long 0x00 "0xe618"
hexmask.long.word 0x00 0.--13. 1. " clip3_rgb  ,Maximum value for input video data of the third channel for RGB pipeline. Values above this are clipped."
hexmask.long.word 0x00 16.--29. 1. " clip4_rgb  ,Maximum value for input video data of the fourth channel for RGB pipeline. Values above this are clipped."
group.long 0xe61c++0x3
line.long 0x00 "0xe61c"
hexmask.long.word 0x00 0.--13. 1. " clip1_luv  ,Maximum value for input video data of the first channel for LUV pipeline. Values above this are clipped."
hexmask.long.word 0x00 16.--29. 1. " clip2_luv  ,Maximum value for input video data of the second channel for LUV pipeline. Values above this are clipped."
group.long 0xe620++0x3
line.long 0x00 "0xe620"
hexmask.long.word 0x00 0.--13. 1. " clip3_luv  ,Maximum value for input video data of the third channel for LUV pipeline. Values above this are clipped."
hexmask.long.word 0x00 16.--29. 1. " clip4_luv  ,Maximum value for input video data of the fourth channel for LUV pipeline. Values above this are clipped."
group.long 0xe624++0x3
line.long 0x00 "0xe624"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_11  ,Matrix coefficient for R-R multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe628++0x3
line.long 0x00 "0xe628"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_12  ,Matrix coefficient for G-R multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe62c++0x3
line.long 0x00 "0xe62c"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_13  ,Matrix coefficient for B-R multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe630++0x3
line.long 0x00 "0xe630"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_14  ,Matrix coefficient for IR-R multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe634++0x3
line.long 0x00 "0xe634"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_21  ,Matrix coefficient for R-G multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe638++0x3
line.long 0x00 "0xe638"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_22  ,Matrix coefficient for G-G multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe63c++0x3
line.long 0x00 "0xe63c"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_23  ,Matrix coefficient for B-G multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe640++0x3
line.long 0x00 "0xe640"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_24  ,Matrix coefficient for IR-G multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe644++0x3
line.long 0x00 "0xe644"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_31  ,Matrix coefficient for R-B multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe648++0x3
line.long 0x00 "0xe648"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_32  ,Matrix coefficient for G-B multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe64c++0x3
line.long 0x00 "0xe64c"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_33  ,Matrix coefficient for B-B multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe650++0x3
line.long 0x00 "0xe650"
hexmask.long.word 0x00 0.--15. 1. " rgb2rgb_coef_a_34  ,Matrix coefficient for IR-B multiplier for RGB pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe654++0x3
line.long 0x00 "0xe654"
hexmask.long.word 0x00 0.--14. 1. " rgb2rgb_coef_b_1  ,Offset for R for RGB pipeline."
group.long 0xe658++0x3
line.long 0x00 "0xe658"
hexmask.long.word 0x00 0.--14. 1. " rgb2rgb_coef_b_2  ,Offset for G for RGB pipeline."
group.long 0xe65c++0x3
line.long 0x00 "0xe65c"
hexmask.long.word 0x00 0.--14. 1. " rgb2rgb_coef_b_3  ,Offset for B for RGB pipeline."
group.long 0xe660++0x3
line.long 0x00 "0xe660"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_11  ,Matrix coefficient for R-X multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe664++0x3
line.long 0x00 "0xe664"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_12  ,Matrix coefficient for G-X multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe668++0x3
line.long 0x00 "0xe668"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_13  ,Matrix coefficient for B-X multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe66c++0x3
line.long 0x00 "0xe66c"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_14  ,Matrix coefficient for IR-X multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe670++0x3
line.long 0x00 "0xe670"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_21  ,Matrix coefficient for R-Y multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe674++0x3
line.long 0x00 "0xe674"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_22  ,Matrix coefficient for G-Y multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe678++0x3
line.long 0x00 "0xe678"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_23  ,Matrix coefficient for B-Y multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe67c++0x3
line.long 0x00 "0xe67c"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_24  ,Matrix coefficient for IR-Y multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe680++0x3
line.long 0x00 "0xe680"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_31  ,Matrix coefficient for R-Z multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe684++0x3
line.long 0x00 "0xe684"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_32  ,Matrix coefficient for G-Z multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe688++0x3
line.long 0x00 "0xe688"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_33  ,Matrix coefficient for B-Z multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe68c++0x3
line.long 0x00 "0xe68c"
hexmask.long.word 0x00 0.--15. 1. " rgb2xyz_coef_a_34  ,Matrix coefficient for IR-Z multiplier for LUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe690++0x3
line.long 0x00 "0xe690"
hexmask.long.word 0x00 0.--14. 1. " rgb2xyz_coef_b_1  ,Offset for X for LUV pipeline."
group.long 0xe694++0x3
line.long 0x00 "0xe694"
hexmask.long.word 0x00 0.--14. 1. " rgb2xyz_coef_b_2  ,Offset for Y for LUV pipeline."
group.long 0xe698++0x3
line.long 0x00 "0xe698"
hexmask.long.word 0x00 0.--14. 1. " rgb2xyz_coef_b_3  ,Offset for Z for LUV pipeline."
group.long 0xe69c++0x3
line.long 0x00 "0xe69c"
hexmask.long.word 0x00 0.--15. 1. " rgb2yuv_coef_a_11  ,Matrix coefficient for R-Y multiplier for YUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe6a0++0x3
line.long 0x00 "0xe6a0"
hexmask.long.word 0x00 0.--15. 1. " rgb2yuv_coef_a_12  ,Matrix coefficient for G-Y multiplier for YUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe6a4++0x3
line.long 0x00 "0xe6a4"
hexmask.long.word 0x00 0.--15. 1. " rgb2yuv_coef_a_13  ,Matrix coefficient for B-Y multiplier for YUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe6a8++0x3
line.long 0x00 "0xe6a8"
hexmask.long.word 0x00 0.--15. 1. " rgb2yuv_coef_a_21  ,Matrix coefficient for R-U multiplier for YUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe6ac++0x3
line.long 0x00 "0xe6ac"
hexmask.long.word 0x00 0.--15. 1. " rgb2yuv_coef_a_22  ,Matrix coefficient for G-U multiplier for YUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe6b0++0x3
line.long 0x00 "0xe6b0"
hexmask.long.word 0x00 0.--15. 1. " rgb2yuv_coef_a_23  ,Matrix coefficient for B-U multiplier for YUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe6b4++0x3
line.long 0x00 "0xe6b4"
hexmask.long.word 0x00 0.--15. 1. " rgb2yuv_coef_a_31  ,Matrix coefficient for R-V multiplier for YUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe6b8++0x3
line.long 0x00 "0xe6b8"
hexmask.long.word 0x00 0.--15. 1. " rgb2yuv_coef_a_32  ,Matrix coefficient for G-V multiplier for YUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe6bc++0x3
line.long 0x00 "0xe6bc"
hexmask.long.word 0x00 0.--15. 1. " rgb2yuv_coef_a_33  ,Matrix coefficient for B-V multiplier for YUV pipeline.        Valid range (decimal): +/- 15.996"
group.long 0xe6c0++0x3
line.long 0x00 "0xe6c0"
hexmask.long.word 0x00 0.--14. 1. " rgb2yuv_coef_b_1  ,Offset for Y for YUV pipeline."
group.long 0xe6c4++0x3
line.long 0x00 "0xe6c4"
hexmask.long.word 0x00 0.--14. 1. " rgb2yuv_coef_b_2  ,Offset for U for YUV pipeline."
group.long 0xe6c8++0x3
line.long 0x00 "0xe6c8"
hexmask.long.word 0x00 0.--14. 1. " rgb2yuv_coef_b_3  ,Offset for V for YUV pipeline."
group.long 0xe6cc++0x3
line.long 0x00 "0xe6cc"
textline "                 "
bitfld.long 0x00 0. " lpf_ab_enable_horiz_downsample  , Horizontal Downsampling Enable for HS pipeline: 0=off 1=on  "
bitfld.long 0x00 1. " lpf_ab_enable_vert_downsample  , Vertical Downsampling Enable for HS pipeline: 0=off 1=on  "
bitfld.long 0x00 2. " lpf_ab_enable_horiz_filter  , Filter Enable for HS pipeline: 0=off 1=on  "
bitfld.long 0x00 3. " lpf_luv_enable_horiz_downsample  , Horizontal Downsampling Enable for LUV pipeline: 0=off 1=on  "
textline "                 "
bitfld.long 0x00 4. " lpf_luv_enable_vert_downsample  , Vertical Downsampling Enable for LUV pipeline: 0=off 1=on  "
bitfld.long 0x00 5. " lpf_luv_enable_horiz_filter  , Filter Enable for LUV pipeline: 0=off 1=on  "
bitfld.long 0x00 6. " lpf_yuv_enable_horiz_downsample  , Horizontal Downsampling Enable for YUV pipeline: 0=off 1=on  "
group.long 0xe6d0++0x3
line.long 0x00 "0xe6d0"
hexmask.long.long 0x00 0.--17. 1. " lut_rgb_mem_data_r_last  ,The last node value for RGB pipeline LUT.       Format for all nodes of this LUT:       if lut_rgb_mem_data_r_last[17:16] = 3 then       format is: signed (2's complement) 15.3-bit fixed-point      else format is: unsigned 15.3-bit fixed-point"
group.long 0xe6d4++0x3
line.long 0x00 "0xe6d4"
hexmask.long.long 0x00 0.--17. 1. " lut_ir_mem_data_r_last  ,The last node value for IR pipeline LUT.       Format for all nodes of this LUT:       if lut_ir_mem_data_r_last[17:16] = 3 then       format is: signed (2's complement) 15.3-bit fixed-point      else format is: unsigned 15.3-bit fixed-point"
group.long 0xe6d8++0x3
line.long 0x00 "0xe6d8"
hexmask.long.long 0x00 0.--17. 1. " lut_yuv_mem_data_r_last_u  ,The last node value for U channel of YUV pipeline LUT.      Format for all nodes of this LUT:      if lut_yuv_mem_data_r_last_u[17:16] = 3 then      format is: signed (2's complement) 15.3-bit fixed-point     else format is: unsigned 15.3-bit fixed-point"
group.long 0xe6dc++0x3
line.long 0x00 "0xe6dc"
hexmask.long.long 0x00 0.--17. 1. " lut_yuv_mem_data_r_last_v  ,The last node value for V channel of YUV pipeline LUT.       Format for all nodes of this LUT:       if lut_yuv_mem_data_r_last_v[17:16] = 3 then       format is: signed (2's complement) 15.3-bit fixed-point      else format is: unsigned 15.3-bit fixed-point"
group.long 0xe6e0++0x3
line.long 0x00 "0xe6e0"
hexmask.long.long 0x00 0.--17. 1. " lut_luv_mem_data_r_last_u  ,The last node value for U channel of LUV pipeline LUT.      Format for all nodes of this LUT:      if lut_luv_mem_data_r_last_u[17:16] = 3 then      format is: signed (2's complement) 15.3-bit fixed-point     else format is: unsigned 15.3-bit fixed-point"
group.long 0xe6e4++0x3
line.long 0x00 "0xe6e4"
hexmask.long.long 0x00 0.--17. 1. " lut_luv_mem_data_r_last_v  ,The last node value for V channel of LUV pipeline LUT.      Format for all nodes of this LUT:      if lut_luv_mem_data_r_last_v[17:16] = 3 then      format is: signed (2's complement) 15.3-bit fixed-point     else format is: unsigned 15.3-bit fixed-point"
TREE.END
TREE "Crop"
group.long 0xe700++0x3
line.long 0x00 "0xe700"
textline "                 "
bitfld.long 0x00 0. " Enable crop  , Crop enable: 0=off 1=on  "
group.long 0xe704++0x3
line.long 0x00 "0xe704"
hexmask.long.word 0x00 0.--15. 1. " start x  ,Horizontal offset from left side of image in pixels for output crop window"
group.long 0xe708++0x3
line.long 0x00 "0xe708"
hexmask.long.word 0x00 0.--15. 1. " start y  ,Vertical offset from top of image in lines for output crop window"
group.long 0xe70c++0x3
line.long 0x00 "0xe70c"
hexmask.long.word 0x00 0.--15. 1. " size x  ,width of output crop window"
group.long 0xe710++0x3
line.long 0x00 "0xe710"
hexmask.long.word 0x00 0.--15. 1. " size y  ,height of output crop window"
TREE.END
TREE "Out format MUX for AXI 1"
group.long 0xe740++0x3
line.long 0x00 "0xe740"
hexmask.long.byte 0x00 0.--4. 1. " Mode select  ,Select the output colourspace. (0=Reserved 0, 1=rgb.R/12, 2=rgb.G/12, 3=rgb.B/12, 4=yuv.Y/12, 5=yuv.U/12, 6=yuv.V/12, 7=yuv.UV/8, 8=yuv.VU/8, 9=S/8, 10=HS/88, 11=luv.L/12, 12=luv.UV/8, 13=IR/12, 14=IR/8, 15=rgb/888, 16=luv.U/12, 17=luv.V/12, 18=S/12, 19=HS.H/12, 20=HS.S/12, 21=SH/88, 22=luv.VU/8, 23=Reserved 23, 24=RAW data 8, 25=RAW data 10, 26=RAW data 12, 27=RAW data 16, 28=Reserved 28, 29=Reserved 29, 30=RAW data full, 31=Reserved 31)"
textline "                 "
bitfld.long 0x00 7. " MSB align  , Output data alignment (0=Align to LSB, 1=Align to MSB)  "
rgroup.long 0xe744++0x3
line.long 0x00 "0xe744"
hexmask.long.byte 0x00 0.--7. 1. " Data width  ,Output data width (informative)"
TREE.END
TREE "Out format MUX for AXI 2"
group.long 0xe740++0x3
line.long 0x00 "0xe740"
hexmask.long.byte 0x00 8.--12. 1. " Mode select  ,Select the output colourspace. (0=Reserved 0, 1=rgb.R/12, 2=rgb.G/12, 3=rgb.B/12, 4=yuv.Y/12, 5=yuv.U/12, 6=yuv.V/12, 7=yuv.UV/8, 8=yuv.VU/8, 9=S/8, 10=HS/88, 11=luv.L/12, 12=luv.UV/8, 13=IR/12, 14=IR/8, 15=rgb/888, 16=luv.U/12, 17=luv.V/12, 18=S/12, 19=HS.H/12, 20=HS.S/12, 21=SH/88, 22=luv.VU/8, 23=Reserved 23, 24=RAW data 8, 25=RAW data 10, 26=RAW data 12, 27=RAW data 16, 28=Reserved 28, 29=Reserved 29, 30=RAW data full, 31=Reserved 31)"
textline "                 "
bitfld.long 0x00 15. " MSB align  , Output data alignment (0=Align to LSB, 1=Align to MSB)  "
rgroup.long 0xe744++0x3
line.long 0x00 "0xe744"
hexmask.long.byte 0x00 8.--15. 1. " Data width  ,Output data width (informative)"
TREE.END
TREE "Out format MUX for AXI 3"
group.long 0xe740++0x3
line.long 0x00 "0xe740"
hexmask.long.byte 0x00 16.--20. 1. " Mode select  ,Select the output colourspace. (0=Reserved 0, 1=rgb.R/12, 2=rgb.G/12, 3=rgb.B/12, 4=yuv.Y/12, 5=yuv.U/12, 6=yuv.V/12, 7=yuv.UV/8, 8=yuv.VU/8, 9=S/8, 10=HS/88, 11=luv.L/12, 12=luv.UV/8, 13=IR/12, 14=IR/8, 15=rgb/888, 16=luv.U/12, 17=luv.V/12, 18=S/12, 19=HS.H/12, 20=HS.S/12, 21=SH/88, 22=luv.VU/8, 23=Reserved 23, 24=RAW data 8, 25=RAW data 10, 26=RAW data 12, 27=RAW data 16, 28=Reserved 28, 29=Reserved 29, 30=RAW data full, 31=Reserved 31)"
textline "                 "
bitfld.long 0x00 23. " MSB align  , Output data alignment (0=Align to LSB, 1=Align to MSB)  "
rgroup.long 0xe744++0x3
line.long 0x00 "0xe744"
hexmask.long.byte 0x00 16.--23. 1. " Data width  ,Output data width (informative)"
TREE.END
TREE "Out format MUX for Output 1"
group.long 0xe750++0x3
line.long 0x00 "0xe750"
hexmask.long.byte 0x00 0.--4. 1. " Mode select  ,Select the output colourspace. (0=Reserved 0, 1=rgb.R/12, 2=rgb.G/12, 3=rgb.B/12, 4=yuv.Y/12, 5=yuv.U/12, 6=yuv.V/12, 7=yuv.UV/8, 8=yuv.VU/8, 9=S/8, 10=HS/88, 11=luv.L/12, 12=luv.UV/8, 13=IR/12, 14=IR/8, 15=rgb/888, 16=luv.U/12, 17=luv.V/12, 18=S/12, 19=HS.H/12, 20=HS.S/12, 21=SH/88, 22=luv.VU/8, 23=Reserved 23, 24=RAW data 8, 25=RAW data 10, 26=RAW data 12, 27=RAW data 16, 28=Reserved 28, 29=Reserved 29, 30=RAW data full, 31=Reserved 31)"
textline "                 "
bitfld.long 0x00 7. " MSB align  , Output data alignment (0=Align to LSB, 1=Align to MSB)  "
rgroup.long 0xe754++0x3
line.long 0x00 "0xe754"
hexmask.long.byte 0x00 0.--7. 1. " Data width  ,Output data width (informative)"
TREE.END
TREE "Out format MUX for Output 2"
group.long 0xe750++0x3
line.long 0x00 "0xe750"
hexmask.long.byte 0x00 8.--12. 1. " Mode select  ,Select the output colourspace. (0=Reserved 0, 1=rgb.R/12, 2=rgb.G/12, 3=rgb.B/12, 4=yuv.Y/12, 5=yuv.U/12, 6=yuv.V/12, 7=yuv.UV/8, 8=yuv.VU/8, 9=S/8, 10=HS/88, 11=luv.L/12, 12=luv.UV/8, 13=IR/12, 14=IR/8, 15=rgb/888, 16=luv.U/12, 17=luv.V/12, 18=S/12, 19=HS.H/12, 20=HS.S/12, 21=SH/88, 22=luv.VU/8, 23=Reserved 23, 24=RAW data 8, 25=RAW data 10, 26=RAW data 12, 27=RAW data 16, 28=Reserved 28, 29=Reserved 29, 30=RAW data full, 31=Reserved 31)"
textline "                 "
bitfld.long 0x00 15. " MSB align  , Output data alignment (0=Align to LSB, 1=Align to MSB)  "
rgroup.long 0xe754++0x3
line.long 0x00 "0xe754"
hexmask.long.byte 0x00 8.--15. 1. " Data width  ,Output data width (informative)"
TREE.END
TREE "Out format MUX for Output 3"
group.long 0xe750++0x3
line.long 0x00 "0xe750"
hexmask.long.byte 0x00 16.--20. 1. " Mode select  ,Select the output colourspace. (0=Reserved 0, 1=rgb.R/12, 2=rgb.G/12, 3=rgb.B/12, 4=yuv.Y/12, 5=yuv.U/12, 6=yuv.V/12, 7=yuv.UV/8, 8=yuv.VU/8, 9=S/8, 10=HS/88, 11=luv.L/12, 12=luv.UV/8, 13=IR/12, 14=IR/8, 15=rgb/888, 16=luv.U/12, 17=luv.V/12, 18=S/12, 19=HS.H/12, 20=HS.S/12, 21=SH/88, 22=luv.VU/8, 23=Reserved 23, 24=RAW data 8, 25=RAW data 10, 26=RAW data 12, 27=RAW data 16, 28=Reserved 28, 29=Reserved 29, 30=RAW data full, 31=Reserved 31)"
textline "                 "
bitfld.long 0x00 23. " MSB align  , Output data alignment (0=Align to LSB, 1=Align to MSB)  "
rgroup.long 0xe754++0x3
line.long 0x00 "0xe754"
hexmask.long.byte 0x00 16.--23. 1. " Data width  ,Output data width (informative)"
TREE.END
TREE "Frame Check isp"
group.long 0xeb00++0x3
line.long 0x00 "0xeb00"
textline "                 "
bitfld.long 0x00 0. " Manual trigger  , Manual triggering of the fault  "
bitfld.long 0x00 1. " Field mode  , 0=pulse; 1=edge  "
group.long 0xeb0c++0x3
line.long 0x00 "0xeb0c"
hexmask.long.long 0x00 0.--31. 1. " Hblank min  ,Expected minimal horizontal blank"
group.long 0xeb10++0x3
line.long 0x00 "0xeb10"
hexmask.long.long 0x00 0.--31. 1. " Hblank max  ,Expected maximal horizontal blank"
group.long 0xeb14++0x3
line.long 0x00 "0xeb14"
hexmask.long.long 0x00 0.--31. 1. " Vblank min  ,Expected minimal vertical blank"
group.long 0xeb18++0x3
line.long 0x00 "0xeb18"
hexmask.long.long 0x00 0.--31. 1. " Vblank max  ,Expected maximal vertical blank"
TREE.END
TREE "Frame Check isp crop"
group.long 0xeb20++0x3
line.long 0x00 "0xeb20"
textline "                 "
bitfld.long 0x00 0. " Manual trigger  , Manual triggering of the fault  "
bitfld.long 0x00 1. " Field mode  , 0=pulse; 1=edge  "
group.long 0xeb24++0x3
line.long 0x00 "0xeb24"
hexmask.long.long 0x00 0.--31. 1. " Active width  ,Expected active width"
group.long 0xeb28++0x3
line.long 0x00 "0xeb28"
hexmask.long.long 0x00 0.--31. 1. " Active height  ,Expected active height"
group.long 0xeb2c++0x3
line.long 0x00 "0xeb2c"
hexmask.long.long 0x00 0.--31. 1. " Hblank min  ,Expected minimal horizontal blank"
group.long 0xeb30++0x3
line.long 0x00 "0xeb30"
hexmask.long.long 0x00 0.--31. 1. " Hblank max  ,Expected maximal horizontal blank"
group.long 0xeb34++0x3
line.long 0x00 "0xeb34"
hexmask.long.long 0x00 0.--31. 1. " Vblank min  ,Expected minimal vertical blank"
group.long 0xeb38++0x3
line.long 0x00 "0xeb38"
hexmask.long.long 0x00 0.--31. 1. " Vblank max  ,Expected maximal vertical blank"
TREE.END
TREE "Frame Check isp out 1"
group.long 0xeb40++0x3
line.long 0x00 "0xeb40"
textline "                 "
bitfld.long 0x00 0. " Manual trigger  , Manual triggering of the fault  "
bitfld.long 0x00 1. " Field mode  , 0=pulse; 1=edge  "
group.long 0xeb44++0x3
line.long 0x00 "0xeb44"
hexmask.long.long 0x00 0.--31. 1. " Active width  ,Expected active width"
group.long 0xeb48++0x3
line.long 0x00 "0xeb48"
hexmask.long.long 0x00 0.--31. 1. " Active height  ,Expected active height"
group.long 0xeb4c++0x3
line.long 0x00 "0xeb4c"
hexmask.long.long 0x00 0.--31. 1. " Hblank min  ,Expected minimal horizontal blank"
group.long 0xeb50++0x3
line.long 0x00 "0xeb50"
hexmask.long.long 0x00 0.--31. 1. " Hblank max  ,Expected maximal horizontal blank"
group.long 0xeb54++0x3
line.long 0x00 "0xeb54"
hexmask.long.long 0x00 0.--31. 1. " Vblank min  ,Expected minimal vertical blank"
group.long 0xeb58++0x3
line.long 0x00 "0xeb58"
hexmask.long.long 0x00 0.--31. 1. " Vblank max  ,Expected maximal vertical blank"
TREE.END
TREE "Frame Check isp out 2"
group.long 0xeb60++0x3
line.long 0x00 "0xeb60"
textline "                 "
bitfld.long 0x00 0. " Manual trigger  , Manual triggering of the fault  "
bitfld.long 0x00 1. " Field mode  , 0=pulse; 1=edge  "
group.long 0xeb64++0x3
line.long 0x00 "0xeb64"
hexmask.long.long 0x00 0.--31. 1. " Active width  ,Expected active width"
group.long 0xeb68++0x3
line.long 0x00 "0xeb68"
hexmask.long.long 0x00 0.--31. 1. " Active height  ,Expected active height"
group.long 0xeb6c++0x3
line.long 0x00 "0xeb6c"
hexmask.long.long 0x00 0.--31. 1. " Hblank min  ,Expected minimal horizontal blank"
group.long 0xeb70++0x3
line.long 0x00 "0xeb70"
hexmask.long.long 0x00 0.--31. 1. " Hblank max  ,Expected maximal horizontal blank"
group.long 0xeb74++0x3
line.long 0x00 "0xeb74"
hexmask.long.long 0x00 0.--31. 1. " Vblank min  ,Expected minimal vertical blank"
group.long 0xeb78++0x3
line.long 0x00 "0xeb78"
hexmask.long.long 0x00 0.--31. 1. " Vblank max  ,Expected maximal vertical blank"
TREE.END
TREE "Frame Check isp out 3"
group.long 0xeb80++0x3
line.long 0x00 "0xeb80"
textline "                 "
bitfld.long 0x00 0. " Manual trigger  , Manual triggering of the fault  "
bitfld.long 0x00 1. " Field mode  , 0=pulse; 1=edge  "
group.long 0xeb84++0x3
line.long 0x00 "0xeb84"
hexmask.long.long 0x00 0.--31. 1. " Active width  ,Expected active width"
group.long 0xeb88++0x3
line.long 0x00 "0xeb88"
hexmask.long.long 0x00 0.--31. 1. " Active height  ,Expected active height"
group.long 0xeb8c++0x3
line.long 0x00 "0xeb8c"
hexmask.long.long 0x00 0.--31. 1. " Hblank min  ,Expected minimal horizontal blank"
group.long 0xeb90++0x3
line.long 0x00 "0xeb90"
hexmask.long.long 0x00 0.--31. 1. " Hblank max  ,Expected maximal horizontal blank"
group.long 0xeb94++0x3
line.long 0x00 "0xeb94"
hexmask.long.long 0x00 0.--31. 1. " Vblank min  ,Expected minimal vertical blank"
group.long 0xeb98++0x3
line.long 0x00 "0xeb98"
hexmask.long.long 0x00 0.--31. 1. " Vblank max  ,Expected maximal vertical blank"
TREE.END
TREE "Module config CRC"
rgroup.long 0xeba0++0x3
line.long 0x00 "0xeba0"
hexmask.long.word 0x00 0.--15. 1. " Raw frontend  ,"
hexmask.long.word 0x00 16.--31. 1. " Defect pixel  ,"
rgroup.long 0xeba4++0x3
line.long 0x00 "0xeba4"
hexmask.long.word 0x00 0.--15. 1. " Frame stitch  ,"
hexmask.long.word 0x00 16.--31. 1. " Sinter  ,"
rgroup.long 0xeba8++0x3
line.long 0x00 "0xeba8"
hexmask.long.word 0x00 0.--15. 1. " Ca correction  ,"
hexmask.long.word 0x00 16.--31. 1. " Gamma fedl  ,"
rgroup.long 0xebac++0x3
line.long 0x00 "0xebac"
hexmask.long.word 0x00 0.--15. 1. " Gamma bedl  ,"
hexmask.long.word 0x00 16.--31. 1. " Radial shading  ,"
rgroup.long 0xebb0++0x3
line.long 0x00 "0xebb0"
hexmask.long.word 0x00 0.--15. 1. " Mesh shading  ,"
hexmask.long.word 0x00 16.--31. 1. " Iridix  ,"
rgroup.long 0xebb4++0x3
line.long 0x00 "0xebb4"
hexmask.long.word 0x00 0.--15. 1. " Demosaic  ,"
hexmask.long.word 0x00 16.--31. 1. " Demosaic rgbir  ,"
rgroup.long 0xebb8++0x3
line.long 0x00 "0xebb8"
hexmask.long.word 0x00 0.--15. 1. " Demosaic rccc  ,"
hexmask.long.word 0x00 16.--31. 1. " Out format  ,"
rgroup.long 0xebbc++0x3
line.long 0x00 "0xebbc"
hexmask.long.word 0x00 0.--15. 1. " metering_aexp  ,"
hexmask.long.word 0x00 16.--31. 1. " metering_awb  ,"
rgroup.long 0xebc0++0x3
line.long 0x00 "0xebc0"
hexmask.long.word 0x00 0.--15. 1. " metering_hist_1  ,"
hexmask.long.word 0x00 16.--31. 1. " metering_hist_2  ,"
rgroup.long 0xebc4++0x3
line.long 0x00 "0xebc4"
hexmask.long.word 0x00 0.--15. 1. " metering_hist_3  ,"
hexmask.long.word 0x00 16.--31. 1. " metering_hist_4  ,"
rgroup.long 0xebc8++0x3
line.long 0x00 "0xebc8"
hexmask.long.word 0x00 0.--15. 1. " roi_hist_1  ,"
hexmask.long.word 0x00 16.--31. 1. " roi_hist_2  ,"
rgroup.long 0xebcc++0x3
line.long 0x00 "0xebcc"
hexmask.long.word 0x00 0.--15. 1. " roi_hist_3  ,"
hexmask.long.word 0x00 16.--31. 1. " roi_hist_4  ,"
rgroup.long 0xebd0++0x3
line.long 0x00 "0xebd0"
hexmask.long.word 0x00 0.--15. 1. " uroi  ,"
hexmask.long.word 0x00 16.--31. 1. " antifog_hist  ,"
TREE.END
TREE "Frame Repeat"
rgroup.long 0xebd4++0x3
line.long 0x00 "0xebd4"
hexmask.long.long 0x00 0.--31. 1. " crc result sensor 1  ,"
rgroup.long 0xebd8++0x3
line.long 0x00 "0xebd8"
hexmask.long.long 0x00 0.--31. 1. " crc result sensor 2  ,"
rgroup.long 0xebdc++0x3
line.long 0x00 "0xebdc"
hexmask.long.long 0x00 0.--31. 1. " crc result sensor 3  ,"
rgroup.long 0xebe0++0x3
line.long 0x00 "0xebe0"
hexmask.long.long 0x00 0.--31. 1. " crc result sensor 4  ,"
rgroup.long 0xebe4++0x3
line.long 0x00 "0xebe4"
hexmask.long.long 0x00 0.--31. 1. " crc result isp  ,"
TREE.END
TREE "BIST CRC check"
rgroup.long 0xebe8++0x3
line.long 0x00 "0xebe8"
hexmask.long.word 0x00 0.--15. 1. " Checksum out 1  ,"
hexmask.long.word 0x00 16.--31. 1. " Checksum out 2  ,"
rgroup.long 0xebec++0x3
line.long 0x00 "0xebec"
hexmask.long.word 0x00 0.--15. 1. " Checksum out 3  ,"
hexmask.long.word 0x00 16.--31. 1. " Checksum out a1  ,"
rgroup.long 0xebf0++0x3
line.long 0x00 "0xebf0"
hexmask.long.word 0x00 0.--15. 1. " Checksum out a2  ,"
hexmask.long.word 0x00 16.--31. 1. " Checksum out a3  ,"
group.long 0xebf4++0x3
line.long 0x00 "0xebf4"
hexmask.long.word 0x00 0.--15. 1. " Checksum 1  ,"
hexmask.long.word 0x00 16.--31. 1. " Checksum 2  ,"
group.long 0xebf8++0x3
line.long 0x00 "0xebf8"
hexmask.long.word 0x00 0.--15. 1. " Checksum 3  ,"
hexmask.long.word 0x00 16.--31. 1. " Checksum a1  ,"
group.long 0xebfc++0x3
line.long 0x00 "0xebfc"
hexmask.long.word 0x00 0.--15. 1. " Checksum a2  ,"
hexmask.long.word 0x00 16.--31. 1. " Checksum a3  ,"
TREE.END
TREE "Statistics"
group.long 0xed80++0x3
line.long 0x00 "0xed80"
hexmask.long.byte 0x00 0.--7. 1. " Hist Thresh 0 1  ,Histogram threshold for bin 0/1 boundary"
group.long 0xed84++0x3
line.long 0x00 "0xed84"
hexmask.long.byte 0x00 0.--7. 1. " Hist Thresh 1 2  ,Histogram threshold for bin 1/2 boundary"
group.long 0xed88++0x3
line.long 0x00 "0xed88"
hexmask.long.byte 0x00 0.--7. 1. " Hist Thresh 3 4  ,Histogram threshold for bin 2/3 boundary"
group.long 0xed8c++0x3
line.long 0x00 "0xed8c"
hexmask.long.byte 0x00 0.--7. 1. " Hist Thresh 4 5  ,Histogram threshold for bin 3/4 boundary"
group.long 0xed90++0x3
line.long 0x00 "0xed90"
hexmask.long.byte 0x00 0.--7. 1. " AEXP Nodes Used Horiz  ,Number of active zones horizontally for AE stats collection"
hexmask.long.byte 0x00 8.--15. 1. " AEXP Nodes Used Vert  ,Number of active zones vertically for AE stats collection"
rgroup.long 0xeda0++0x3
line.long 0x00 "0xeda0"
hexmask.long.word 0x00 0.--15. 1. " Hist 0  ,Normalized histogram results for bin 0"
rgroup.long 0xeda4++0x3
line.long 0x00 "0xeda4"
hexmask.long.word 0x00 0.--15. 1. " Hist 1  ,Normalized histogram results for bin 1"
rgroup.long 0xeda8++0x3
line.long 0x00 "0xeda8"
hexmask.long.word 0x00 0.--15. 1. " Hist 3  ,Normalized histogram results for bin 3"
rgroup.long 0xedac++0x3
line.long 0x00 "0xedac"
hexmask.long.word 0x00 0.--15. 1. " Hist 4  ,Normalized histogram results for bin 4"
group.long 0xedc0++0x3
line.long 0x00 "0xedc0"
hexmask.long.byte 0x00 0.--7. 1. " AWB Nodes Used Horiz  ,Number of active zones horizontally for AWB stats"
hexmask.long.byte 0x00 8.--15. 1. " AWB Nodes Used Vert  ,Number of active zones vertically for AWB stats"
textline "                 "
bitfld.long 0x00 16. " AWB stats mode  , Statistics mode: 0 - legacy(G/R,B/R), 1 - current (R/G, B/G)  "
group.long 0xedc4++0x3
line.long 0x00 "0xedc4"
hexmask.long.word 0x00 0.--9. 1. " White Level AWB  ,Upper limit of valid data for AWB"
group.long 0xedc8++0x3
line.long 0x00 "0xedc8"
hexmask.long.word 0x00 0.--9. 1. " Black Level AWB  ,Lower limit of valid data for AWB"
group.long 0xedcc++0x3
line.long 0x00 "0xedcc"
hexmask.long.word 0x00 0.--11. 1. " Cr Ref Max AWB  ,Maximum value of R/G for white region"
group.long 0xedd0++0x3
line.long 0x00 "0xedd0"
hexmask.long.word 0x00 0.--11. 1. " Cr Ref Min AWB  ,Minimum value of R/G for white region"
group.long 0xedd4++0x3
line.long 0x00 "0xedd4"
hexmask.long.word 0x00 0.--11. 1. " Cb Ref Max AWB  ,Maximum value of B/G for white region"
group.long 0xedd8++0x3
line.long 0x00 "0xedd8"
hexmask.long.word 0x00 0.--11. 1. " Cb Ref Min AWB  ,Minimum value of B/G for white region"
group.long 0xeddc++0x3
line.long 0x00 "0xeddc"
hexmask.long.word 0x00 0.--11. 1. " Cr Ref High AWB  ,Maximum value of R/G for white region"
group.long 0xede0++0x3
line.long 0x00 "0xede0"
hexmask.long.word 0x00 0.--11. 1. " Cr Ref Low AWB  ,Minimum value of R/G for white region"
group.long 0xede4++0x3
line.long 0x00 "0xede4"
hexmask.long.word 0x00 0.--11. 1. " Cb Ref High AWB  ,Maximum value of B/G for white region"
group.long 0xede8++0x3
line.long 0x00 "0xede8"
hexmask.long.word 0x00 0.--11. 1. " Cb Ref Low AWB  ,Minimum value of B/G for white region"
group.long 0xedec++0x3
line.long 0x00 "0xedec"
hexmask.long.word 0x00 0.--15. 1. " AWB Active Width  ,Active video width in pixels for AWB. 0=same as TOP."
hexmask.long.word 0x00 16.--31. 1. " AWB Active Height  ,Active video height in lines for AWB. 0=same as TOP"
rgroup.long 0xedf0++0x3
line.long 0x00 "0xedf0"
hexmask.long.word 0x00 0.--11. 1. " AWB RG  ,AWB statistics R/G color ratio output"
rgroup.long 0xedf4++0x3
line.long 0x00 "0xedf4"
hexmask.long.word 0x00 0.--11. 1. " AWB BG  ,AWB statistics B/G color ratio output"
rgroup.long 0xedf8++0x3
line.long 0x00 "0xedf8"
hexmask.long.long 0x00 0.--31. 1. " AWB SUM  ,AWB output population.  Number of pixels used for AWB statistics"
TREE.END
TREE "Micro ROI"
group.long 0xee00++0x3
line.long 0x00 "0xee00"
hexmask.long.byte 0x00 0.--4. 1. " Select1  ,Select tap point to collect the data for ROI 1 (0=MCFE outputchannel 1, 1=MCFE output, channel 2, 2=MCFE output, channel 3, 3=MCFE output, channel 4, 4=WDR Stitched frame, MSB, 5=WDR Stitched frame, LSB, 6=After lens shading, MSB, 7=After lens shading, LSB, 8=After tone mapping, MSB, 9=After tone mapping, LSB, 10=After demosaic, channel 1, 11=After demosaic, channel 2, 12=After demosaic, channel 3, 13=After demosaic, channel 4, 14=YCbCr output, Y, 15=Luv output, L, 16=YCbCr output, Cb+Cr, 17=Luv output, u+v, 18=HS output, 19=Reserved 19, 20=Reserved 20, 21=Reserved 21, 22=Reserved 22, 23=Reserved 23, 24=Reserved 24, 25=Reserved 25, 26=Reserved 26, 27=Reserved 27, 28=Reserved 28, 29=Reserved 29, 30=Reserved 30, 31=Reserved 31)"
textline "                 "
bitfld.long 0x00 6. " Enable 1  , Enable statistics collection for ROI 1  "
group.long 0xee04++0x3
line.long 0x00 "0xee04"
hexmask.long.word 0x00 0.--12. 1. " Pos x 1  ,Horizontal position of top left corner of ROI 1"
group.long 0xee08++0x3
line.long 0x00 "0xee08"
hexmask.long.word 0x00 0.--12. 1. " Pos y 1  ,Vertical position of the top lef corner of ROI 1"
group.long 0xee0c++0x3
line.long 0x00 "0xee0c"
hexmask.long.byte 0x00 0.--4. 1. " Select2  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 2  , Same as Enable 1  "
group.long 0xee10++0x3
line.long 0x00 "0xee10"
hexmask.long.word 0x00 0.--12. 1. " Pos x 2  ,Same as Pos x 1"
group.long 0xee14++0x3
line.long 0x00 "0xee14"
hexmask.long.word 0x00 0.--12. 1. " Pos y 2  ,Same as Pos y 1"
group.long 0xee18++0x3
line.long 0x00 "0xee18"
hexmask.long.byte 0x00 0.--4. 1. " Select3  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 3  , Same as Enable 1  "
group.long 0xee1c++0x3
line.long 0x00 "0xee1c"
hexmask.long.word 0x00 0.--12. 1. " Pos x 3  ,Same as Pos x 1"
group.long 0xee20++0x3
line.long 0x00 "0xee20"
hexmask.long.word 0x00 0.--12. 1. " Pos y 3  ,Same as Pos y 1"
group.long 0xee24++0x3
line.long 0x00 "0xee24"
hexmask.long.byte 0x00 0.--4. 1. " Select4  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 4  , Same as Enable 1  "
group.long 0xee28++0x3
line.long 0x00 "0xee28"
hexmask.long.word 0x00 0.--12. 1. " Pos x 4  ,Same as Pos x 1"
group.long 0xee2c++0x3
line.long 0x00 "0xee2c"
hexmask.long.word 0x00 0.--12. 1. " Pos y 4  ,Same as Pos y 1"
group.long 0xee30++0x3
line.long 0x00 "0xee30"
hexmask.long.byte 0x00 0.--4. 1. " Select5  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 5  , Same as Enable 1  "
group.long 0xee34++0x3
line.long 0x00 "0xee34"
hexmask.long.word 0x00 0.--12. 1. " Pos x 5  ,Same as Pos x 1"
group.long 0xee38++0x3
line.long 0x00 "0xee38"
hexmask.long.word 0x00 0.--12. 1. " Pos y 5  ,Same as Pos y 1"
group.long 0xee3c++0x3
line.long 0x00 "0xee3c"
hexmask.long.byte 0x00 0.--4. 1. " Select6  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 6  , Same as Enable 1  "
group.long 0xee40++0x3
line.long 0x00 "0xee40"
hexmask.long.word 0x00 0.--12. 1. " Pos x 6  ,Same as Pos x 1"
group.long 0xee44++0x3
line.long 0x00 "0xee44"
hexmask.long.word 0x00 0.--12. 1. " Pos y 6  ,Same as Pos y 1"
group.long 0xee48++0x3
line.long 0x00 "0xee48"
hexmask.long.byte 0x00 0.--4. 1. " Select7  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 7  , Same as Enable 1  "
group.long 0xee4c++0x3
line.long 0x00 "0xee4c"
hexmask.long.word 0x00 0.--12. 1. " Pos x 7  ,Same as Pos x 1"
group.long 0xee50++0x3
line.long 0x00 "0xee50"
hexmask.long.word 0x00 0.--12. 1. " Pos y 7  ,Same as Pos y 1"
group.long 0xee54++0x3
line.long 0x00 "0xee54"
hexmask.long.byte 0x00 0.--4. 1. " Select8  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 8  , Same as Enable 1  "
group.long 0xee58++0x3
line.long 0x00 "0xee58"
hexmask.long.word 0x00 0.--12. 1. " Pos x 8  ,Same as Pos x 1"
group.long 0xee5c++0x3
line.long 0x00 "0xee5c"
hexmask.long.word 0x00 0.--12. 1. " Pos y 8  ,Same as Pos y 1"
group.long 0xee60++0x3
line.long 0x00 "0xee60"
hexmask.long.byte 0x00 0.--4. 1. " Select9  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 9  , Same as Enable 1  "
group.long 0xee64++0x3
line.long 0x00 "0xee64"
hexmask.long.word 0x00 0.--12. 1. " Pos x 9  ,Same as Pos x 1"
group.long 0xee68++0x3
line.long 0x00 "0xee68"
hexmask.long.word 0x00 0.--12. 1. " Pos y 9  ,Same as Pos y 1"
group.long 0xee6c++0x3
line.long 0x00 "0xee6c"
hexmask.long.byte 0x00 0.--4. 1. " Select10  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 10  , Same as Enable 1  "
group.long 0xee70++0x3
line.long 0x00 "0xee70"
hexmask.long.word 0x00 0.--12. 1. " Pos x 10  ,Same as Pos x 1"
group.long 0xee74++0x3
line.long 0x00 "0xee74"
hexmask.long.word 0x00 0.--12. 1. " Pos y 10  ,Same as Pos y 1"
group.long 0xee78++0x3
line.long 0x00 "0xee78"
hexmask.long.byte 0x00 0.--4. 1. " Select11  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 11  , Same as Enable 1  "
group.long 0xee7c++0x3
line.long 0x00 "0xee7c"
hexmask.long.word 0x00 0.--12. 1. " Pos x 11  ,Same as Pos x 1"
group.long 0xee80++0x3
line.long 0x00 "0xee80"
hexmask.long.word 0x00 0.--12. 1. " Pos y 11  ,Same as Pos y 1"
group.long 0xee84++0x3
line.long 0x00 "0xee84"
hexmask.long.byte 0x00 0.--4. 1. " Select12  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 12  , Same as Enable 1  "
group.long 0xee88++0x3
line.long 0x00 "0xee88"
hexmask.long.word 0x00 0.--12. 1. " Pos x 12  ,Same as Pos x 1"
group.long 0xee8c++0x3
line.long 0x00 "0xee8c"
hexmask.long.word 0x00 0.--12. 1. " Pos y 12  ,Same as Pos y 1"
group.long 0xee90++0x3
line.long 0x00 "0xee90"
hexmask.long.byte 0x00 0.--4. 1. " Select13  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 13  , Same as Enable 1  "
group.long 0xee94++0x3
line.long 0x00 "0xee94"
hexmask.long.word 0x00 0.--12. 1. " Pos x 13  ,Same as Pos x 1"
group.long 0xee98++0x3
line.long 0x00 "0xee98"
hexmask.long.word 0x00 0.--12. 1. " Pos y 13  ,Same as Pos y 1"
group.long 0xee9c++0x3
line.long 0x00 "0xee9c"
hexmask.long.byte 0x00 0.--4. 1. " Select14  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 14  , Same as Enable 1  "
group.long 0xeea0++0x3
line.long 0x00 "0xeea0"
hexmask.long.word 0x00 0.--12. 1. " Pos x 14  ,Same as Pos x 1"
group.long 0xeea4++0x3
line.long 0x00 "0xeea4"
hexmask.long.word 0x00 0.--12. 1. " Pos y 14  ,Same as Pos y 1"
group.long 0xeea8++0x3
line.long 0x00 "0xeea8"
hexmask.long.byte 0x00 0.--4. 1. " Select15  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 15  , Same as Enable 1  "
group.long 0xeeac++0x3
line.long 0x00 "0xeeac"
hexmask.long.word 0x00 0.--12. 1. " Pos x 15  ,Same as Pos x 1"
group.long 0xeeb0++0x3
line.long 0x00 "0xeeb0"
hexmask.long.word 0x00 0.--12. 1. " Pos y 15  ,Same as Pos y 1"
group.long 0xeeb4++0x3
line.long 0x00 "0xeeb4"
hexmask.long.byte 0x00 0.--4. 1. " Select16  ,Same as select 1"
textline "                 "
bitfld.long 0x00 6. " Enable 16  , Same as Enable 1  "
group.long 0xeeb8++0x3
line.long 0x00 "0xeeb8"
hexmask.long.word 0x00 0.--12. 1. " Pos x 16  ,Same as Pos x 1"
group.long 0xeebc++0x3
line.long 0x00 "0xeebc"
hexmask.long.word 0x00 0.--12. 1. " Pos y 16  ,Same as Pos y 1"
TREE.END
TREE "Antifog Hist"
group.long 0xef80++0x3
line.long 0x00 "0xef80"
hexmask.long.byte 0x00 0.--2. 1. " skip x  ,Histogram decimation in horizontal direction: 0=every 2nd pixel; 1=every 3rd pixel; 2=every 4th pixel; 3=every 5th pixel; 4=every 8th pixel ; 5+=every 9th pixel"
hexmask.long.byte 0x00 4.--6. 1. " skip y  ,Histogram decimation in vertical direction: 0=every pixel; 1=every 2nd pixel; 2=every 3rd pixel; 3=every 4th pixel; 4=every 5th pixel; 5=every 8th pixel ; 6+=every 9th pixel"
textline "                 "
bitfld.long 0x00 3. " offset x  , 0= start from the first column;  1=start from second column  "
bitfld.long 0x00 7. " offset y  , 0= start from the first row; 1= start from second row  "
hexmask.long.byte 0x00 8.--10. 1. " Plane mode  ,Plane separation mode (0=Collect all the planes in one histogram, 1=Collect 4 Bayer planes into 4 separate banks, 2=Collect every pixel of 4 Bayer planes into 4 separate banks, 3=Reserved 3, 4=Collect odd  x odd  y plane to bank 0, rest to bank 1, 5=Collect even x odd  y plane to bank 0, rest to bank 1, 6=Collect odd  x even y plane to bank 0, rest to bank 1, 7=Collect even x even y plane to bank 0, rest to bank 1)"
textline "                 "
bitfld.long 0x00 12. " Radial shading enable  , Enable radial shading correction.  "
hexmask.long.byte 0x00 16.--23. 1. " Nodes Used Horiz  ,Number of active zones horizontally for AE stats collection"
hexmask.long.byte 0x00 24.--31. 1. " Nodes Used Vert  ,Number of active zones vertically for AE stats collection"
group.long 0xef84++0x3
line.long 0x00 "0xef84"
hexmask.long.byte 0x00 0.--3. 1. " scale bottom  ,scale of bottom half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
hexmask.long.byte 0x00 4.--7. 1. " scale top  ,scale of top half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
rgroup.long 0xef88++0x3
line.long 0x00 "0xef88"
hexmask.long.long 0x00 0.--31. 1. " Total Pixels  ,Total number of pixels processed (skip x and skip y are taken into account)"
rgroup.long 0xef8c++0x3
line.long 0x00 "0xef8c"
hexmask.long.long 0x00 0.--31. 1. " Counted Pixels  ,Number of pixels accumulated (with nonzero weight)"
group.long 0x0++0x10
group.long 0x0++0x10
group.long 0xefb0++0x3
line.long 0x00 "0xefb0"
hexmask.long.word 0x00 0.--11. 1. " Gain 00  ,Multiplier for color channel 00 (R)"
group.long 0xefb4++0x3
line.long 0x00 "0xefb4"
hexmask.long.word 0x00 0.--11. 1. " Gain 01  ,Multiplier for color channel 01 (Gr)"
group.long 0xefb8++0x3
line.long 0x00 "0xefb8"
hexmask.long.word 0x00 0.--11. 1. " Gain 10  ,Multiplier for color channel 10 (Gb)"
group.long 0xefbc++0x3
line.long 0x00 "0xefbc"
hexmask.long.word 0x00 0.--11. 1. " Gain 11  ,Multiplier for color channel 11 (B)"
group.long 0xefc0++0x3
line.long 0x00 "0xefc0"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xefc4++0x3
line.long 0x00 "0xefc4"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xefc8++0x3
line.long 0x00 "0xefc8"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xefcc++0x3
line.long 0x00 "0xefcc"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
group.long 0xefd0++0x3
line.long 0x00 "0xefd0"
hexmask.long.word 0x00 0.--15. 1. " Center X  ,Center x coordinate of the shading map"
group.long 0xefd4++0x3
line.long 0x00 "0xefd4"
hexmask.long.word 0x00 0.--15. 1. " Center Y  ,Center y coordinate of the shading map"
group.long 0xefd8++0x3
line.long 0x00 "0xefd8"
hexmask.long.word 0x00 0.--15. 1. " Off Center multx  ,Normalizing X factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
hexmask.long.word 0x00 16.--31. 1. " Off Center multy  ,Normalizing Y factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xf000++0xe5
line.quad 0x00 "0xf000"
hexmask.long.byte 0x0 0.--3. 1. " Weight Table[0|0]         , "
hexmask.long.byte 0x0 8.--11. 1. "  [1|0] , "
hexmask.long.byte 0x0 16.--19. 1. "  [2|0] , "
hexmask.long.byte 0x0 24.--27. 1. "  [3|0] , "
hexmask.long.byte 0x4 0.--3. 1. "  [4|0] , "
hexmask.long.byte 0x4 8.--11. 1. "  [5|0] , "
hexmask.long.byte 0x4 16.--19. 1. "  [6|0] , "
hexmask.long.byte 0x4 24.--27. 1. "  [7|0] , "
hexmask.long.byte 0x8 0.--3. 1. "  [8|0] , "
hexmask.long.byte 0x8 8.--11. 1. "  [9|0] , "
hexmask.long.byte 0x8 16.--19. 1. "  [10|0] , "
hexmask.long.byte 0x8 24.--27. 1. "  [11|0] , "
hexmask.long.byte 0xc 0.--3. 1. "  [12|0] , "
hexmask.long.byte 0xc 8.--11. 1. "  [13|0] , "
hexmask.long.byte 0xc 16.--19. 1. "  [14|0] , "
line.quad 0x0f "0xf00f"
hexmask.long.byte 0xc 24.--27. 1. " Weight Table[0|1]         , "
hexmask.long.byte 0x10 0.--3. 1. "  [1|1] , "
hexmask.long.byte 0x10 8.--11. 1. "  [2|1] , "
hexmask.long.byte 0x10 16.--19. 1. "  [3|1] , "
hexmask.long.byte 0x10 24.--27. 1. "  [4|1] , "
hexmask.long.byte 0x14 0.--3. 1. "  [5|1] , "
hexmask.long.byte 0x14 8.--11. 1. "  [6|1] , "
hexmask.long.byte 0x14 16.--19. 1. "  [7|1] , "
hexmask.long.byte 0x14 24.--27. 1. "  [8|1] , "
hexmask.long.byte 0x18 0.--3. 1. "  [9|1] , "
hexmask.long.byte 0x18 8.--11. 1. "  [10|1] , "
hexmask.long.byte 0x18 16.--19. 1. "  [11|1] , "
hexmask.long.byte 0x18 24.--27. 1. "  [12|1] , "
hexmask.long.byte 0x1c 0.--3. 1. "  [13|1] , "
hexmask.long.byte 0x1c 8.--11. 1. "  [14|1] , "
line.quad 0x1e "0xf01e"
hexmask.long.byte 0x1c 16.--19. 1. " Weight Table[0|2]         , "
hexmask.long.byte 0x1c 24.--27. 1. "  [1|2] , "
hexmask.long.byte 0x20 0.--3. 1. "  [2|2] , "
hexmask.long.byte 0x20 8.--11. 1. "  [3|2] , "
hexmask.long.byte 0x20 16.--19. 1. "  [4|2] , "
hexmask.long.byte 0x20 24.--27. 1. "  [5|2] , "
hexmask.long.byte 0x24 0.--3. 1. "  [6|2] , "
hexmask.long.byte 0x24 8.--11. 1. "  [7|2] , "
hexmask.long.byte 0x24 16.--19. 1. "  [8|2] , "
hexmask.long.byte 0x24 24.--27. 1. "  [9|2] , "
hexmask.long.byte 0x28 0.--3. 1. "  [10|2] , "
hexmask.long.byte 0x28 8.--11. 1. "  [11|2] , "
hexmask.long.byte 0x28 16.--19. 1. "  [12|2] , "
hexmask.long.byte 0x28 24.--27. 1. "  [13|2] , "
hexmask.long.byte 0x2c 0.--3. 1. "  [14|2] , "
line.quad 0x2d "0xf02d"
hexmask.long.byte 0x2c 8.--11. 1. " Weight Table[0|3]         , "
hexmask.long.byte 0x2c 16.--19. 1. "  [1|3] , "
hexmask.long.byte 0x2c 24.--27. 1. "  [2|3] , "
hexmask.long.byte 0x30 0.--3. 1. "  [3|3] , "
hexmask.long.byte 0x30 8.--11. 1. "  [4|3] , "
hexmask.long.byte 0x30 16.--19. 1. "  [5|3] , "
hexmask.long.byte 0x30 24.--27. 1. "  [6|3] , "
hexmask.long.byte 0x34 0.--3. 1. "  [7|3] , "
hexmask.long.byte 0x34 8.--11. 1. "  [8|3] , "
hexmask.long.byte 0x34 16.--19. 1. "  [9|3] , "
hexmask.long.byte 0x34 24.--27. 1. "  [10|3] , "
hexmask.long.byte 0x38 0.--3. 1. "  [11|3] , "
hexmask.long.byte 0x38 8.--11. 1. "  [12|3] , "
hexmask.long.byte 0x38 16.--19. 1. "  [13|3] , "
hexmask.long.byte 0x38 24.--27. 1. "  [14|3] , "
line.quad 0x3c "0xf03c"
hexmask.long.byte 0x3c 0.--3. 1. " Weight Table[0|4]         , "
hexmask.long.byte 0x3c 8.--11. 1. "  [1|4] , "
hexmask.long.byte 0x3c 16.--19. 1. "  [2|4] , "
hexmask.long.byte 0x3c 24.--27. 1. "  [3|4] , "
hexmask.long.byte 0x40 0.--3. 1. "  [4|4] , "
hexmask.long.byte 0x40 8.--11. 1. "  [5|4] , "
hexmask.long.byte 0x40 16.--19. 1. "  [6|4] , "
hexmask.long.byte 0x40 24.--27. 1. "  [7|4] , "
hexmask.long.byte 0x44 0.--3. 1. "  [8|4] , "
hexmask.long.byte 0x44 8.--11. 1. "  [9|4] , "
hexmask.long.byte 0x44 16.--19. 1. "  [10|4] , "
hexmask.long.byte 0x44 24.--27. 1. "  [11|4] , "
hexmask.long.byte 0x48 0.--3. 1. "  [12|4] , "
hexmask.long.byte 0x48 8.--11. 1. "  [13|4] , "
hexmask.long.byte 0x48 16.--19. 1. "  [14|4] , "
line.quad 0x4b "0xf04b"
hexmask.long.byte 0x48 24.--27. 1. " Weight Table[0|5]         , "
hexmask.long.byte 0x4c 0.--3. 1. "  [1|5] , "
hexmask.long.byte 0x4c 8.--11. 1. "  [2|5] , "
hexmask.long.byte 0x4c 16.--19. 1. "  [3|5] , "
hexmask.long.byte 0x4c 24.--27. 1. "  [4|5] , "
hexmask.long.byte 0x50 0.--3. 1. "  [5|5] , "
hexmask.long.byte 0x50 8.--11. 1. "  [6|5] , "
hexmask.long.byte 0x50 16.--19. 1. "  [7|5] , "
hexmask.long.byte 0x50 24.--27. 1. "  [8|5] , "
hexmask.long.byte 0x54 0.--3. 1. "  [9|5] , "
hexmask.long.byte 0x54 8.--11. 1. "  [10|5] , "
hexmask.long.byte 0x54 16.--19. 1. "  [11|5] , "
hexmask.long.byte 0x54 24.--27. 1. "  [12|5] , "
hexmask.long.byte 0x58 0.--3. 1. "  [13|5] , "
hexmask.long.byte 0x58 8.--11. 1. "  [14|5] , "
line.quad 0x5a "0xf05a"
hexmask.long.byte 0x58 16.--19. 1. " Weight Table[0|6]         , "
hexmask.long.byte 0x58 24.--27. 1. "  [1|6] , "
hexmask.long.byte 0x5c 0.--3. 1. "  [2|6] , "
hexmask.long.byte 0x5c 8.--11. 1. "  [3|6] , "
hexmask.long.byte 0x5c 16.--19. 1. "  [4|6] , "
hexmask.long.byte 0x5c 24.--27. 1. "  [5|6] , "
hexmask.long.byte 0x60 0.--3. 1. "  [6|6] , "
hexmask.long.byte 0x60 8.--11. 1. "  [7|6] , "
hexmask.long.byte 0x60 16.--19. 1. "  [8|6] , "
hexmask.long.byte 0x60 24.--27. 1. "  [9|6] , "
hexmask.long.byte 0x64 0.--3. 1. "  [10|6] , "
hexmask.long.byte 0x64 8.--11. 1. "  [11|6] , "
hexmask.long.byte 0x64 16.--19. 1. "  [12|6] , "
hexmask.long.byte 0x64 24.--27. 1. "  [13|6] , "
hexmask.long.byte 0x68 0.--3. 1. "  [14|6] , "
line.quad 0x69 "0xf069"
hexmask.long.byte 0x68 8.--11. 1. " Weight Table[0|7]         , "
hexmask.long.byte 0x68 16.--19. 1. "  [1|7] , "
hexmask.long.byte 0x68 24.--27. 1. "  [2|7] , "
hexmask.long.byte 0x6c 0.--3. 1. "  [3|7] , "
hexmask.long.byte 0x6c 8.--11. 1. "  [4|7] , "
hexmask.long.byte 0x6c 16.--19. 1. "  [5|7] , "
hexmask.long.byte 0x6c 24.--27. 1. "  [6|7] , "
hexmask.long.byte 0x70 0.--3. 1. "  [7|7] , "
hexmask.long.byte 0x70 8.--11. 1. "  [8|7] , "
hexmask.long.byte 0x70 16.--19. 1. "  [9|7] , "
hexmask.long.byte 0x70 24.--27. 1. "  [10|7] , "
hexmask.long.byte 0x74 0.--3. 1. "  [11|7] , "
hexmask.long.byte 0x74 8.--11. 1. "  [12|7] , "
hexmask.long.byte 0x74 16.--19. 1. "  [13|7] , "
hexmask.long.byte 0x74 24.--27. 1. "  [14|7] , "
line.quad 0x78 "0xf078"
hexmask.long.byte 0x78 0.--3. 1. " Weight Table[0|8]         , "
hexmask.long.byte 0x78 8.--11. 1. "  [1|8] , "
hexmask.long.byte 0x78 16.--19. 1. "  [2|8] , "
hexmask.long.byte 0x78 24.--27. 1. "  [3|8] , "
hexmask.long.byte 0x7c 0.--3. 1. "  [4|8] , "
hexmask.long.byte 0x7c 8.--11. 1. "  [5|8] , "
hexmask.long.byte 0x7c 16.--19. 1. "  [6|8] , "
hexmask.long.byte 0x7c 24.--27. 1. "  [7|8] , "
hexmask.long.byte 0x80 0.--3. 1. "  [8|8] , "
hexmask.long.byte 0x80 8.--11. 1. "  [9|8] , "
hexmask.long.byte 0x80 16.--19. 1. "  [10|8] , "
hexmask.long.byte 0x80 24.--27. 1. "  [11|8] , "
hexmask.long.byte 0x84 0.--3. 1. "  [12|8] , "
hexmask.long.byte 0x84 8.--11. 1. "  [13|8] , "
hexmask.long.byte 0x84 16.--19. 1. "  [14|8] , "
line.quad 0x87 "0xf087"
hexmask.long.byte 0x84 24.--27. 1. " Weight Table[0|9]         , "
hexmask.long.byte 0x88 0.--3. 1. "  [1|9] , "
hexmask.long.byte 0x88 8.--11. 1. "  [2|9] , "
hexmask.long.byte 0x88 16.--19. 1. "  [3|9] , "
hexmask.long.byte 0x88 24.--27. 1. "  [4|9] , "
hexmask.long.byte 0x8c 0.--3. 1. "  [5|9] , "
hexmask.long.byte 0x8c 8.--11. 1. "  [6|9] , "
hexmask.long.byte 0x8c 16.--19. 1. "  [7|9] , "
hexmask.long.byte 0x8c 24.--27. 1. "  [8|9] , "
hexmask.long.byte 0x90 0.--3. 1. "  [9|9] , "
hexmask.long.byte 0x90 8.--11. 1. "  [10|9] , "
hexmask.long.byte 0x90 16.--19. 1. "  [11|9] , "
hexmask.long.byte 0x90 24.--27. 1. "  [12|9] , "
hexmask.long.byte 0x94 0.--3. 1. "  [13|9] , "
hexmask.long.byte 0x94 8.--11. 1. "  [14|9] , "
line.quad 0x96 "0xf096"
hexmask.long.byte 0x94 16.--19. 1. " Weight Table[0|10]        , "
hexmask.long.byte 0x94 24.--27. 1. "  [1|10] , "
hexmask.long.byte 0x98 0.--3. 1. "  [2|10] , "
hexmask.long.byte 0x98 8.--11. 1. "  [3|10] , "
hexmask.long.byte 0x98 16.--19. 1. "  [4|10] , "
hexmask.long.byte 0x98 24.--27. 1. "  [5|10] , "
hexmask.long.byte 0x9c 0.--3. 1. "  [6|10] , "
hexmask.long.byte 0x9c 8.--11. 1. "  [7|10] , "
hexmask.long.byte 0x9c 16.--19. 1. "  [8|10] , "
hexmask.long.byte 0x9c 24.--27. 1. "  [9|10] , "
hexmask.long.byte 0xa0 0.--3. 1. "  [10|10] , "
hexmask.long.byte 0xa0 8.--11. 1. "  [11|10] , "
hexmask.long.byte 0xa0 16.--19. 1. "  [12|10] , "
hexmask.long.byte 0xa0 24.--27. 1. "  [13|10] , "
hexmask.long.byte 0xa4 0.--3. 1. "  [14|10] , "
line.quad 0xa5 "0xf0a5"
hexmask.long.byte 0xa4 8.--11. 1. " Weight Table[0|11]        , "
hexmask.long.byte 0xa4 16.--19. 1. "  [1|11] , "
hexmask.long.byte 0xa4 24.--27. 1. "  [2|11] , "
hexmask.long.byte 0xa8 0.--3. 1. "  [3|11] , "
hexmask.long.byte 0xa8 8.--11. 1. "  [4|11] , "
hexmask.long.byte 0xa8 16.--19. 1. "  [5|11] , "
hexmask.long.byte 0xa8 24.--27. 1. "  [6|11] , "
hexmask.long.byte 0xac 0.--3. 1. "  [7|11] , "
hexmask.long.byte 0xac 8.--11. 1. "  [8|11] , "
hexmask.long.byte 0xac 16.--19. 1. "  [9|11] , "
hexmask.long.byte 0xac 24.--27. 1. "  [10|11] , "
hexmask.long.byte 0xb0 0.--3. 1. "  [11|11] , "
hexmask.long.byte 0xb0 8.--11. 1. "  [12|11] , "
hexmask.long.byte 0xb0 16.--19. 1. "  [13|11] , "
hexmask.long.byte 0xb0 24.--27. 1. "  [14|11] , "
line.quad 0xb4 "0xf0b4"
hexmask.long.byte 0xb4 0.--3. 1. " Weight Table[0|12]        , "
hexmask.long.byte 0xb4 8.--11. 1. "  [1|12] , "
hexmask.long.byte 0xb4 16.--19. 1. "  [2|12] , "
hexmask.long.byte 0xb4 24.--27. 1. "  [3|12] , "
hexmask.long.byte 0xb8 0.--3. 1. "  [4|12] , "
hexmask.long.byte 0xb8 8.--11. 1. "  [5|12] , "
hexmask.long.byte 0xb8 16.--19. 1. "  [6|12] , "
hexmask.long.byte 0xb8 24.--27. 1. "  [7|12] , "
hexmask.long.byte 0xbc 0.--3. 1. "  [8|12] , "
hexmask.long.byte 0xbc 8.--11. 1. "  [9|12] , "
hexmask.long.byte 0xbc 16.--19. 1. "  [10|12] , "
hexmask.long.byte 0xbc 24.--27. 1. "  [11|12] , "
hexmask.long.byte 0xc0 0.--3. 1. "  [12|12] , "
hexmask.long.byte 0xc0 8.--11. 1. "  [13|12] , "
hexmask.long.byte 0xc0 16.--19. 1. "  [14|12] , "
line.quad 0xc3 "0xf0c3"
hexmask.long.byte 0xc0 24.--27. 1. " Weight Table[0|13]        , "
hexmask.long.byte 0xc4 0.--3. 1. "  [1|13] , "
hexmask.long.byte 0xc4 8.--11. 1. "  [2|13] , "
hexmask.long.byte 0xc4 16.--19. 1. "  [3|13] , "
hexmask.long.byte 0xc4 24.--27. 1. "  [4|13] , "
hexmask.long.byte 0xc8 0.--3. 1. "  [5|13] , "
hexmask.long.byte 0xc8 8.--11. 1. "  [6|13] , "
hexmask.long.byte 0xc8 16.--19. 1. "  [7|13] , "
hexmask.long.byte 0xc8 24.--27. 1. "  [8|13] , "
hexmask.long.byte 0xcc 0.--3. 1. "  [9|13] , "
hexmask.long.byte 0xcc 8.--11. 1. "  [10|13] , "
hexmask.long.byte 0xcc 16.--19. 1. "  [11|13] , "
hexmask.long.byte 0xcc 24.--27. 1. "  [12|13] , "
hexmask.long.byte 0xd0 0.--3. 1. "  [13|13] , "
hexmask.long.byte 0xd0 8.--11. 1. "  [14|13] , "
line.quad 0xd2 "0xf0d2"
hexmask.long.byte 0xd0 16.--19. 1. " Weight Table[0|14]        , "
hexmask.long.byte 0xd0 24.--27. 1. "  [1|14] , "
hexmask.long.byte 0xd4 0.--3. 1. "  [2|14] , "
hexmask.long.byte 0xd4 8.--11. 1. "  [3|14] , "
hexmask.long.byte 0xd4 16.--19. 1. "  [4|14] , "
hexmask.long.byte 0xd4 24.--27. 1. "  [5|14] , "
hexmask.long.byte 0xd8 0.--3. 1. "  [6|14] , "
hexmask.long.byte 0xd8 8.--11. 1. "  [7|14] , "
hexmask.long.byte 0xd8 16.--19. 1. "  [8|14] , "
hexmask.long.byte 0xd8 24.--27. 1. "  [9|14] , "
hexmask.long.byte 0xdc 0.--3. 1. "  [10|14] , "
hexmask.long.byte 0xdc 8.--11. 1. "  [11|14] , "
hexmask.long.byte 0xdc 16.--19. 1. "  [12|14] , "
hexmask.long.byte 0xdc 24.--27. 1. "  [13|14] , "
hexmask.long.byte 0xe0 0.--3. 1. "  [14|14] , "
TREE.END
TREE "Metering Hist 1"
group.long 0xf100++0x3
line.long 0x00 "0xf100"
hexmask.long.byte 0x00 0.--2. 1. " skip x  ,Histogram decimation in horizontal direction: 0=every 2nd pixel; 1=every 3rd pixel; 2=every 4th pixel; 3=every 5th pixel; 4=every 8th pixel ; 5+=every 9th pixel"
hexmask.long.byte 0x00 4.--6. 1. " skip y  ,Histogram decimation in vertical direction: 0=every pixel; 1=every 2nd pixel; 2=every 3rd pixel; 3=every 4th pixel; 4=every 5th pixel; 5=every 8th pixel ; 6+=every 9th pixel"
textline "                 "
bitfld.long 0x00 3. " offset x  , 0= start from the first column;  1=start from second column  "
bitfld.long 0x00 7. " offset y  , 0= start from the first row; 1= start from second row  "
hexmask.long.byte 0x00 8.--10. 1. " Plane mode  ,Plane separation mode (0=Collect all the planes in one histogram, 1=Collect 4 Bayer planes into 4 separate banks, 2=Collect every pixel of 4 Bayer planes into 4 separate banks, 3=Reserved 3, 4=Collect odd  x odd  y plane to bank 0, rest to bank 1, 5=Collect even x odd  y plane to bank 0, rest to bank 1, 6=Collect odd  x even y plane to bank 0, rest to bank 1, 7=Collect even x even y plane to bank 0, rest to bank 1)"
textline "                 "
bitfld.long 0x00 12. " Radial shading enable  , Enable radial shading correction.  "
hexmask.long.byte 0x00 16.--23. 1. " Nodes Used Horiz  ,Number of active zones horizontally for AE stats collection"
hexmask.long.byte 0x00 24.--31. 1. " Nodes Used Vert  ,Number of active zones vertically for AE stats collection"
group.long 0xf104++0x3
line.long 0x00 "0xf104"
hexmask.long.byte 0x00 0.--3. 1. " scale bottom  ,scale of bottom half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
hexmask.long.byte 0x00 4.--7. 1. " scale top  ,scale of top half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
rgroup.long 0xf108++0x3
line.long 0x00 "0xf108"
hexmask.long.long 0x00 0.--31. 1. " Total Pixels  ,Total number of pixels processed (skip x and skip y are taken into account)"
rgroup.long 0xf10c++0x3
line.long 0x00 "0xf10c"
hexmask.long.long 0x00 0.--31. 1. " Counted Pixels  ,Number of pixels accumulated (with nonzero weight)"
group.long 0x0++0x10
group.long 0x0++0x10
group.long 0xf130++0x3
line.long 0x00 "0xf130"
hexmask.long.word 0x00 0.--11. 1. " Gain 00  ,Multiplier for color channel 00 (R)"
group.long 0xf134++0x3
line.long 0x00 "0xf134"
hexmask.long.word 0x00 0.--11. 1. " Gain 01  ,Multiplier for color channel 01 (Gr)"
group.long 0xf138++0x3
line.long 0x00 "0xf138"
hexmask.long.word 0x00 0.--11. 1. " Gain 10  ,Multiplier for color channel 10 (Gb)"
group.long 0xf13c++0x3
line.long 0x00 "0xf13c"
hexmask.long.word 0x00 0.--11. 1. " Gain 11  ,Multiplier for color channel 11 (B)"
group.long 0xf140++0x3
line.long 0x00 "0xf140"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xf144++0x3
line.long 0x00 "0xf144"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xf148++0x3
line.long 0x00 "0xf148"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xf14c++0x3
line.long 0x00 "0xf14c"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
group.long 0xf150++0x3
line.long 0x00 "0xf150"
hexmask.long.word 0x00 0.--15. 1. " Center X  ,Center x coordinate of the shading map"
group.long 0xf154++0x3
line.long 0x00 "0xf154"
hexmask.long.word 0x00 0.--15. 1. " Center Y  ,Center y coordinate of the shading map"
group.long 0xf158++0x3
line.long 0x00 "0xf158"
hexmask.long.word 0x00 0.--15. 1. " Off Center multx  ,Normalizing X factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xf15c++0x3
line.long 0x00 "0xf15c"
hexmask.long.word 0x00 0.--15. 1. " Off Center multy  ,Normalizing Y factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xf160++0x3
line.long 0x00 "0xf160"
hexmask.long.word 0x00 0.--15. 1. " Active Width  ,Active video width in pixels"
group.long 0xf164++0x3
line.long 0x00 "0xf164"
hexmask.long.word 0x00 0.--15. 1. " Active Height  ,Active video height in lines"
group.long 0xf168++0x3
line.long 0x00 "0xf168"
hexmask.long.byte 0x00 0.--1. 1. " RGGB start  ,Starting color of the rggb pattern (0=R Gr   Gb B, 1=Gr R   B Gb, 2=Gb B   R Gr, 3=B Gb   Gr R)"
hexmask.long.byte 0x00 4.--5. 1. " CFA pattern  ,Pattern select: (0=RGGB, 1=RCCC, 2=RIrGB, 3=RGIrB)"
group.long 0xf190++0xe5
line.quad 0x00 "0xf190"
hexmask.long.byte 0x0 0.--3. 1. " Weight Table[0|0]         , "
hexmask.long.byte 0x0 8.--11. 1. "  [1|0] , "
hexmask.long.byte 0x0 16.--19. 1. "  [2|0] , "
hexmask.long.byte 0x0 24.--27. 1. "  [3|0] , "
hexmask.long.byte 0x4 0.--3. 1. "  [4|0] , "
hexmask.long.byte 0x4 8.--11. 1. "  [5|0] , "
hexmask.long.byte 0x4 16.--19. 1. "  [6|0] , "
hexmask.long.byte 0x4 24.--27. 1. "  [7|0] , "
hexmask.long.byte 0x8 0.--3. 1. "  [8|0] , "
hexmask.long.byte 0x8 8.--11. 1. "  [9|0] , "
hexmask.long.byte 0x8 16.--19. 1. "  [10|0] , "
hexmask.long.byte 0x8 24.--27. 1. "  [11|0] , "
hexmask.long.byte 0xc 0.--3. 1. "  [12|0] , "
hexmask.long.byte 0xc 8.--11. 1. "  [13|0] , "
hexmask.long.byte 0xc 16.--19. 1. "  [14|0] , "
line.quad 0x0f "0xf19f"
hexmask.long.byte 0xc 24.--27. 1. " Weight Table[0|1]         , "
hexmask.long.byte 0x10 0.--3. 1. "  [1|1] , "
hexmask.long.byte 0x10 8.--11. 1. "  [2|1] , "
hexmask.long.byte 0x10 16.--19. 1. "  [3|1] , "
hexmask.long.byte 0x10 24.--27. 1. "  [4|1] , "
hexmask.long.byte 0x14 0.--3. 1. "  [5|1] , "
hexmask.long.byte 0x14 8.--11. 1. "  [6|1] , "
hexmask.long.byte 0x14 16.--19. 1. "  [7|1] , "
hexmask.long.byte 0x14 24.--27. 1. "  [8|1] , "
hexmask.long.byte 0x18 0.--3. 1. "  [9|1] , "
hexmask.long.byte 0x18 8.--11. 1. "  [10|1] , "
hexmask.long.byte 0x18 16.--19. 1. "  [11|1] , "
hexmask.long.byte 0x18 24.--27. 1. "  [12|1] , "
hexmask.long.byte 0x1c 0.--3. 1. "  [13|1] , "
hexmask.long.byte 0x1c 8.--11. 1. "  [14|1] , "
line.quad 0x1e "0xf1ae"
hexmask.long.byte 0x1c 16.--19. 1. " Weight Table[0|2]         , "
hexmask.long.byte 0x1c 24.--27. 1. "  [1|2] , "
hexmask.long.byte 0x20 0.--3. 1. "  [2|2] , "
hexmask.long.byte 0x20 8.--11. 1. "  [3|2] , "
hexmask.long.byte 0x20 16.--19. 1. "  [4|2] , "
hexmask.long.byte 0x20 24.--27. 1. "  [5|2] , "
hexmask.long.byte 0x24 0.--3. 1. "  [6|2] , "
hexmask.long.byte 0x24 8.--11. 1. "  [7|2] , "
hexmask.long.byte 0x24 16.--19. 1. "  [8|2] , "
hexmask.long.byte 0x24 24.--27. 1. "  [9|2] , "
hexmask.long.byte 0x28 0.--3. 1. "  [10|2] , "
hexmask.long.byte 0x28 8.--11. 1. "  [11|2] , "
hexmask.long.byte 0x28 16.--19. 1. "  [12|2] , "
hexmask.long.byte 0x28 24.--27. 1. "  [13|2] , "
hexmask.long.byte 0x2c 0.--3. 1. "  [14|2] , "
line.quad 0x2d "0xf1bd"
hexmask.long.byte 0x2c 8.--11. 1. " Weight Table[0|3]         , "
hexmask.long.byte 0x2c 16.--19. 1. "  [1|3] , "
hexmask.long.byte 0x2c 24.--27. 1. "  [2|3] , "
hexmask.long.byte 0x30 0.--3. 1. "  [3|3] , "
hexmask.long.byte 0x30 8.--11. 1. "  [4|3] , "
hexmask.long.byte 0x30 16.--19. 1. "  [5|3] , "
hexmask.long.byte 0x30 24.--27. 1. "  [6|3] , "
hexmask.long.byte 0x34 0.--3. 1. "  [7|3] , "
hexmask.long.byte 0x34 8.--11. 1. "  [8|3] , "
hexmask.long.byte 0x34 16.--19. 1. "  [9|3] , "
hexmask.long.byte 0x34 24.--27. 1. "  [10|3] , "
hexmask.long.byte 0x38 0.--3. 1. "  [11|3] , "
hexmask.long.byte 0x38 8.--11. 1. "  [12|3] , "
hexmask.long.byte 0x38 16.--19. 1. "  [13|3] , "
hexmask.long.byte 0x38 24.--27. 1. "  [14|3] , "
line.quad 0x3c "0xf1cc"
hexmask.long.byte 0x3c 0.--3. 1. " Weight Table[0|4]         , "
hexmask.long.byte 0x3c 8.--11. 1. "  [1|4] , "
hexmask.long.byte 0x3c 16.--19. 1. "  [2|4] , "
hexmask.long.byte 0x3c 24.--27. 1. "  [3|4] , "
hexmask.long.byte 0x40 0.--3. 1. "  [4|4] , "
hexmask.long.byte 0x40 8.--11. 1. "  [5|4] , "
hexmask.long.byte 0x40 16.--19. 1. "  [6|4] , "
hexmask.long.byte 0x40 24.--27. 1. "  [7|4] , "
hexmask.long.byte 0x44 0.--3. 1. "  [8|4] , "
hexmask.long.byte 0x44 8.--11. 1. "  [9|4] , "
hexmask.long.byte 0x44 16.--19. 1. "  [10|4] , "
hexmask.long.byte 0x44 24.--27. 1. "  [11|4] , "
hexmask.long.byte 0x48 0.--3. 1. "  [12|4] , "
hexmask.long.byte 0x48 8.--11. 1. "  [13|4] , "
hexmask.long.byte 0x48 16.--19. 1. "  [14|4] , "
line.quad 0x4b "0xf1db"
hexmask.long.byte 0x48 24.--27. 1. " Weight Table[0|5]         , "
hexmask.long.byte 0x4c 0.--3. 1. "  [1|5] , "
hexmask.long.byte 0x4c 8.--11. 1. "  [2|5] , "
hexmask.long.byte 0x4c 16.--19. 1. "  [3|5] , "
hexmask.long.byte 0x4c 24.--27. 1. "  [4|5] , "
hexmask.long.byte 0x50 0.--3. 1. "  [5|5] , "
hexmask.long.byte 0x50 8.--11. 1. "  [6|5] , "
hexmask.long.byte 0x50 16.--19. 1. "  [7|5] , "
hexmask.long.byte 0x50 24.--27. 1. "  [8|5] , "
hexmask.long.byte 0x54 0.--3. 1. "  [9|5] , "
hexmask.long.byte 0x54 8.--11. 1. "  [10|5] , "
hexmask.long.byte 0x54 16.--19. 1. "  [11|5] , "
hexmask.long.byte 0x54 24.--27. 1. "  [12|5] , "
hexmask.long.byte 0x58 0.--3. 1. "  [13|5] , "
hexmask.long.byte 0x58 8.--11. 1. "  [14|5] , "
line.quad 0x5a "0xf1ea"
hexmask.long.byte 0x58 16.--19. 1. " Weight Table[0|6]         , "
hexmask.long.byte 0x58 24.--27. 1. "  [1|6] , "
hexmask.long.byte 0x5c 0.--3. 1. "  [2|6] , "
hexmask.long.byte 0x5c 8.--11. 1. "  [3|6] , "
hexmask.long.byte 0x5c 16.--19. 1. "  [4|6] , "
hexmask.long.byte 0x5c 24.--27. 1. "  [5|6] , "
hexmask.long.byte 0x60 0.--3. 1. "  [6|6] , "
hexmask.long.byte 0x60 8.--11. 1. "  [7|6] , "
hexmask.long.byte 0x60 16.--19. 1. "  [8|6] , "
hexmask.long.byte 0x60 24.--27. 1. "  [9|6] , "
hexmask.long.byte 0x64 0.--3. 1. "  [10|6] , "
hexmask.long.byte 0x64 8.--11. 1. "  [11|6] , "
hexmask.long.byte 0x64 16.--19. 1. "  [12|6] , "
hexmask.long.byte 0x64 24.--27. 1. "  [13|6] , "
hexmask.long.byte 0x68 0.--3. 1. "  [14|6] , "
line.quad 0x69 "0xf1f9"
hexmask.long.byte 0x68 8.--11. 1. " Weight Table[0|7]         , "
hexmask.long.byte 0x68 16.--19. 1. "  [1|7] , "
hexmask.long.byte 0x68 24.--27. 1. "  [2|7] , "
hexmask.long.byte 0x6c 0.--3. 1. "  [3|7] , "
hexmask.long.byte 0x6c 8.--11. 1. "  [4|7] , "
hexmask.long.byte 0x6c 16.--19. 1. "  [5|7] , "
hexmask.long.byte 0x6c 24.--27. 1. "  [6|7] , "
hexmask.long.byte 0x70 0.--3. 1. "  [7|7] , "
hexmask.long.byte 0x70 8.--11. 1. "  [8|7] , "
hexmask.long.byte 0x70 16.--19. 1. "  [9|7] , "
hexmask.long.byte 0x70 24.--27. 1. "  [10|7] , "
hexmask.long.byte 0x74 0.--3. 1. "  [11|7] , "
hexmask.long.byte 0x74 8.--11. 1. "  [12|7] , "
hexmask.long.byte 0x74 16.--19. 1. "  [13|7] , "
hexmask.long.byte 0x74 24.--27. 1. "  [14|7] , "
line.quad 0x78 "0xf208"
hexmask.long.byte 0x78 0.--3. 1. " Weight Table[0|8]         , "
hexmask.long.byte 0x78 8.--11. 1. "  [1|8] , "
hexmask.long.byte 0x78 16.--19. 1. "  [2|8] , "
hexmask.long.byte 0x78 24.--27. 1. "  [3|8] , "
hexmask.long.byte 0x7c 0.--3. 1. "  [4|8] , "
hexmask.long.byte 0x7c 8.--11. 1. "  [5|8] , "
hexmask.long.byte 0x7c 16.--19. 1. "  [6|8] , "
hexmask.long.byte 0x7c 24.--27. 1. "  [7|8] , "
hexmask.long.byte 0x80 0.--3. 1. "  [8|8] , "
hexmask.long.byte 0x80 8.--11. 1. "  [9|8] , "
hexmask.long.byte 0x80 16.--19. 1. "  [10|8] , "
hexmask.long.byte 0x80 24.--27. 1. "  [11|8] , "
hexmask.long.byte 0x84 0.--3. 1. "  [12|8] , "
hexmask.long.byte 0x84 8.--11. 1. "  [13|8] , "
hexmask.long.byte 0x84 16.--19. 1. "  [14|8] , "
line.quad 0x87 "0xf217"
hexmask.long.byte 0x84 24.--27. 1. " Weight Table[0|9]         , "
hexmask.long.byte 0x88 0.--3. 1. "  [1|9] , "
hexmask.long.byte 0x88 8.--11. 1. "  [2|9] , "
hexmask.long.byte 0x88 16.--19. 1. "  [3|9] , "
hexmask.long.byte 0x88 24.--27. 1. "  [4|9] , "
hexmask.long.byte 0x8c 0.--3. 1. "  [5|9] , "
hexmask.long.byte 0x8c 8.--11. 1. "  [6|9] , "
hexmask.long.byte 0x8c 16.--19. 1. "  [7|9] , "
hexmask.long.byte 0x8c 24.--27. 1. "  [8|9] , "
hexmask.long.byte 0x90 0.--3. 1. "  [9|9] , "
hexmask.long.byte 0x90 8.--11. 1. "  [10|9] , "
hexmask.long.byte 0x90 16.--19. 1. "  [11|9] , "
hexmask.long.byte 0x90 24.--27. 1. "  [12|9] , "
hexmask.long.byte 0x94 0.--3. 1. "  [13|9] , "
hexmask.long.byte 0x94 8.--11. 1. "  [14|9] , "
line.quad 0x96 "0xf226"
hexmask.long.byte 0x94 16.--19. 1. " Weight Table[0|10]        , "
hexmask.long.byte 0x94 24.--27. 1. "  [1|10] , "
hexmask.long.byte 0x98 0.--3. 1. "  [2|10] , "
hexmask.long.byte 0x98 8.--11. 1. "  [3|10] , "
hexmask.long.byte 0x98 16.--19. 1. "  [4|10] , "
hexmask.long.byte 0x98 24.--27. 1. "  [5|10] , "
hexmask.long.byte 0x9c 0.--3. 1. "  [6|10] , "
hexmask.long.byte 0x9c 8.--11. 1. "  [7|10] , "
hexmask.long.byte 0x9c 16.--19. 1. "  [8|10] , "
hexmask.long.byte 0x9c 24.--27. 1. "  [9|10] , "
hexmask.long.byte 0xa0 0.--3. 1. "  [10|10] , "
hexmask.long.byte 0xa0 8.--11. 1. "  [11|10] , "
hexmask.long.byte 0xa0 16.--19. 1. "  [12|10] , "
hexmask.long.byte 0xa0 24.--27. 1. "  [13|10] , "
hexmask.long.byte 0xa4 0.--3. 1. "  [14|10] , "
line.quad 0xa5 "0xf235"
hexmask.long.byte 0xa4 8.--11. 1. " Weight Table[0|11]        , "
hexmask.long.byte 0xa4 16.--19. 1. "  [1|11] , "
hexmask.long.byte 0xa4 24.--27. 1. "  [2|11] , "
hexmask.long.byte 0xa8 0.--3. 1. "  [3|11] , "
hexmask.long.byte 0xa8 8.--11. 1. "  [4|11] , "
hexmask.long.byte 0xa8 16.--19. 1. "  [5|11] , "
hexmask.long.byte 0xa8 24.--27. 1. "  [6|11] , "
hexmask.long.byte 0xac 0.--3. 1. "  [7|11] , "
hexmask.long.byte 0xac 8.--11. 1. "  [8|11] , "
hexmask.long.byte 0xac 16.--19. 1. "  [9|11] , "
hexmask.long.byte 0xac 24.--27. 1. "  [10|11] , "
hexmask.long.byte 0xb0 0.--3. 1. "  [11|11] , "
hexmask.long.byte 0xb0 8.--11. 1. "  [12|11] , "
hexmask.long.byte 0xb0 16.--19. 1. "  [13|11] , "
hexmask.long.byte 0xb0 24.--27. 1. "  [14|11] , "
line.quad 0xb4 "0xf244"
hexmask.long.byte 0xb4 0.--3. 1. " Weight Table[0|12]        , "
hexmask.long.byte 0xb4 8.--11. 1. "  [1|12] , "
hexmask.long.byte 0xb4 16.--19. 1. "  [2|12] , "
hexmask.long.byte 0xb4 24.--27. 1. "  [3|12] , "
hexmask.long.byte 0xb8 0.--3. 1. "  [4|12] , "
hexmask.long.byte 0xb8 8.--11. 1. "  [5|12] , "
hexmask.long.byte 0xb8 16.--19. 1. "  [6|12] , "
hexmask.long.byte 0xb8 24.--27. 1. "  [7|12] , "
hexmask.long.byte 0xbc 0.--3. 1. "  [8|12] , "
hexmask.long.byte 0xbc 8.--11. 1. "  [9|12] , "
hexmask.long.byte 0xbc 16.--19. 1. "  [10|12] , "
hexmask.long.byte 0xbc 24.--27. 1. "  [11|12] , "
hexmask.long.byte 0xc0 0.--3. 1. "  [12|12] , "
hexmask.long.byte 0xc0 8.--11. 1. "  [13|12] , "
hexmask.long.byte 0xc0 16.--19. 1. "  [14|12] , "
line.quad 0xc3 "0xf253"
hexmask.long.byte 0xc0 24.--27. 1. " Weight Table[0|13]        , "
hexmask.long.byte 0xc4 0.--3. 1. "  [1|13] , "
hexmask.long.byte 0xc4 8.--11. 1. "  [2|13] , "
hexmask.long.byte 0xc4 16.--19. 1. "  [3|13] , "
hexmask.long.byte 0xc4 24.--27. 1. "  [4|13] , "
hexmask.long.byte 0xc8 0.--3. 1. "  [5|13] , "
hexmask.long.byte 0xc8 8.--11. 1. "  [6|13] , "
hexmask.long.byte 0xc8 16.--19. 1. "  [7|13] , "
hexmask.long.byte 0xc8 24.--27. 1. "  [8|13] , "
hexmask.long.byte 0xcc 0.--3. 1. "  [9|13] , "
hexmask.long.byte 0xcc 8.--11. 1. "  [10|13] , "
hexmask.long.byte 0xcc 16.--19. 1. "  [11|13] , "
hexmask.long.byte 0xcc 24.--27. 1. "  [12|13] , "
hexmask.long.byte 0xd0 0.--3. 1. "  [13|13] , "
hexmask.long.byte 0xd0 8.--11. 1. "  [14|13] , "
line.quad 0xd2 "0xf262"
hexmask.long.byte 0xd0 16.--19. 1. " Weight Table[0|14]        , "
hexmask.long.byte 0xd0 24.--27. 1. "  [1|14] , "
hexmask.long.byte 0xd4 0.--3. 1. "  [2|14] , "
hexmask.long.byte 0xd4 8.--11. 1. "  [3|14] , "
hexmask.long.byte 0xd4 16.--19. 1. "  [4|14] , "
hexmask.long.byte 0xd4 24.--27. 1. "  [5|14] , "
hexmask.long.byte 0xd8 0.--3. 1. "  [6|14] , "
hexmask.long.byte 0xd8 8.--11. 1. "  [7|14] , "
hexmask.long.byte 0xd8 16.--19. 1. "  [8|14] , "
hexmask.long.byte 0xd8 24.--27. 1. "  [9|14] , "
hexmask.long.byte 0xdc 0.--3. 1. "  [10|14] , "
hexmask.long.byte 0xdc 8.--11. 1. "  [11|14] , "
hexmask.long.byte 0xdc 16.--19. 1. "  [12|14] , "
hexmask.long.byte 0xdc 24.--27. 1. "  [13|14] , "
hexmask.long.byte 0xe0 0.--3. 1. "  [14|14] , "
TREE.END
TREE "Metering Hist 2"
group.long 0xf280++0x3
line.long 0x00 "0xf280"
hexmask.long.byte 0x00 0.--2. 1. " skip x  ,Histogram decimation in horizontal direction: 0=every 2nd pixel; 1=every 3rd pixel; 2=every 4th pixel; 3=every 5th pixel; 4=every 8th pixel ; 5+=every 9th pixel"
hexmask.long.byte 0x00 4.--6. 1. " skip y  ,Histogram decimation in vertical direction: 0=every pixel; 1=every 2nd pixel; 2=every 3rd pixel; 3=every 4th pixel; 4=every 5th pixel; 5=every 8th pixel ; 6+=every 9th pixel"
textline "                 "
bitfld.long 0x00 3. " offset x  , 0= start from the first column;  1=start from second column  "
bitfld.long 0x00 7. " offset y  , 0= start from the first row; 1= start from second row  "
hexmask.long.byte 0x00 8.--10. 1. " Plane mode  ,Plane separation mode (0=Collect all the planes in one histogram, 1=Collect 4 Bayer planes into 4 separate banks, 2=Collect every pixel of 4 Bayer planes into 4 separate banks, 3=Reserved 3, 4=Collect odd  x odd  y plane to bank 0, rest to bank 1, 5=Collect even x odd  y plane to bank 0, rest to bank 1, 6=Collect odd  x even y plane to bank 0, rest to bank 1, 7=Collect even x even y plane to bank 0, rest to bank 1)"
textline "                 "
bitfld.long 0x00 12. " Radial shading enable  , Enable radial shading correction.  "
hexmask.long.byte 0x00 16.--23. 1. " Nodes Used Horiz  ,Number of active zones horizontally for AE stats collection"
hexmask.long.byte 0x00 24.--31. 1. " Nodes Used Vert  ,Number of active zones vertically for AE stats collection"
group.long 0xf284++0x3
line.long 0x00 "0xf284"
hexmask.long.byte 0x00 0.--3. 1. " scale bottom  ,scale of bottom half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
hexmask.long.byte 0x00 4.--7. 1. " scale top  ,scale of top half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
rgroup.long 0xf288++0x3
line.long 0x00 "0xf288"
hexmask.long.long 0x00 0.--31. 1. " Total Pixels  ,Total number of pixels processed (skip x and skip y are taken into account)"
rgroup.long 0xf28c++0x3
line.long 0x00 "0xf28c"
hexmask.long.long 0x00 0.--31. 1. " Counted Pixels  ,Number of pixels accumulated (with nonzero weight)"
group.long 0x0++0x10
group.long 0x0++0x10
group.long 0xf2b0++0x3
line.long 0x00 "0xf2b0"
hexmask.long.word 0x00 0.--11. 1. " Gain 00  ,Multiplier for color channel 00 (R)"
group.long 0xf2b4++0x3
line.long 0x00 "0xf2b4"
hexmask.long.word 0x00 0.--11. 1. " Gain 01  ,Multiplier for color channel 01 (Gr)"
group.long 0xf2b8++0x3
line.long 0x00 "0xf2b8"
hexmask.long.word 0x00 0.--11. 1. " Gain 10  ,Multiplier for color channel 10 (Gb)"
group.long 0xf2bc++0x3
line.long 0x00 "0xf2bc"
hexmask.long.word 0x00 0.--11. 1. " Gain 11  ,Multiplier for color channel 11 (B)"
group.long 0xf2c0++0x3
line.long 0x00 "0xf2c0"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xf2c4++0x3
line.long 0x00 "0xf2c4"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xf2c8++0x3
line.long 0x00 "0xf2c8"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xf2cc++0x3
line.long 0x00 "0xf2cc"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
group.long 0xf2d0++0x3
line.long 0x00 "0xf2d0"
hexmask.long.word 0x00 0.--15. 1. " Center X  ,Center x coordinate of the shading map"
group.long 0xf2d4++0x3
line.long 0x00 "0xf2d4"
hexmask.long.word 0x00 0.--15. 1. " Center Y  ,Center y coordinate of the shading map"
group.long 0xf2d8++0x3
line.long 0x00 "0xf2d8"
hexmask.long.word 0x00 0.--15. 1. " Off Center multx  ,Normalizing X factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xf2dc++0x3
line.long 0x00 "0xf2dc"
hexmask.long.word 0x00 0.--15. 1. " Off Center multy  ,Normalizing Y factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xf2e0++0x3
line.long 0x00 "0xf2e0"
hexmask.long.word 0x00 0.--15. 1. " Active Width  ,Active video width in pixels"
group.long 0xf2e4++0x3
line.long 0x00 "0xf2e4"
hexmask.long.word 0x00 0.--15. 1. " Active Height  ,Active video height in lines"
group.long 0xf2e8++0x3
line.long 0x00 "0xf2e8"
hexmask.long.byte 0x00 0.--1. 1. " RGGB start  ,Starting color of the rggb pattern (0=R Gr   Gb B, 1=Gr R   B Gb, 2=Gb B   R Gr, 3=B Gb   Gr R)"
hexmask.long.byte 0x00 4.--5. 1. " CFA pattern  ,Pattern select: (0=RGGB, 1=RCCC, 2=RIrGB, 3=RGIrB)"
group.long 0xf310++0xe5
line.quad 0x00 "0xf310"
hexmask.long.byte 0x0 0.--3. 1. " Weight Table[0|0]         , "
hexmask.long.byte 0x0 8.--11. 1. "  [1|0] , "
hexmask.long.byte 0x0 16.--19. 1. "  [2|0] , "
hexmask.long.byte 0x0 24.--27. 1. "  [3|0] , "
hexmask.long.byte 0x4 0.--3. 1. "  [4|0] , "
hexmask.long.byte 0x4 8.--11. 1. "  [5|0] , "
hexmask.long.byte 0x4 16.--19. 1. "  [6|0] , "
hexmask.long.byte 0x4 24.--27. 1. "  [7|0] , "
hexmask.long.byte 0x8 0.--3. 1. "  [8|0] , "
hexmask.long.byte 0x8 8.--11. 1. "  [9|0] , "
hexmask.long.byte 0x8 16.--19. 1. "  [10|0] , "
hexmask.long.byte 0x8 24.--27. 1. "  [11|0] , "
hexmask.long.byte 0xc 0.--3. 1. "  [12|0] , "
hexmask.long.byte 0xc 8.--11. 1. "  [13|0] , "
hexmask.long.byte 0xc 16.--19. 1. "  [14|0] , "
line.quad 0x0f "0xf31f"
hexmask.long.byte 0xc 24.--27. 1. " Weight Table[0|1]         , "
hexmask.long.byte 0x10 0.--3. 1. "  [1|1] , "
hexmask.long.byte 0x10 8.--11. 1. "  [2|1] , "
hexmask.long.byte 0x10 16.--19. 1. "  [3|1] , "
hexmask.long.byte 0x10 24.--27. 1. "  [4|1] , "
hexmask.long.byte 0x14 0.--3. 1. "  [5|1] , "
hexmask.long.byte 0x14 8.--11. 1. "  [6|1] , "
hexmask.long.byte 0x14 16.--19. 1. "  [7|1] , "
hexmask.long.byte 0x14 24.--27. 1. "  [8|1] , "
hexmask.long.byte 0x18 0.--3. 1. "  [9|1] , "
hexmask.long.byte 0x18 8.--11. 1. "  [10|1] , "
hexmask.long.byte 0x18 16.--19. 1. "  [11|1] , "
hexmask.long.byte 0x18 24.--27. 1. "  [12|1] , "
hexmask.long.byte 0x1c 0.--3. 1. "  [13|1] , "
hexmask.long.byte 0x1c 8.--11. 1. "  [14|1] , "
line.quad 0x1e "0xf32e"
hexmask.long.byte 0x1c 16.--19. 1. " Weight Table[0|2]         , "
hexmask.long.byte 0x1c 24.--27. 1. "  [1|2] , "
hexmask.long.byte 0x20 0.--3. 1. "  [2|2] , "
hexmask.long.byte 0x20 8.--11. 1. "  [3|2] , "
hexmask.long.byte 0x20 16.--19. 1. "  [4|2] , "
hexmask.long.byte 0x20 24.--27. 1. "  [5|2] , "
hexmask.long.byte 0x24 0.--3. 1. "  [6|2] , "
hexmask.long.byte 0x24 8.--11. 1. "  [7|2] , "
hexmask.long.byte 0x24 16.--19. 1. "  [8|2] , "
hexmask.long.byte 0x24 24.--27. 1. "  [9|2] , "
hexmask.long.byte 0x28 0.--3. 1. "  [10|2] , "
hexmask.long.byte 0x28 8.--11. 1. "  [11|2] , "
hexmask.long.byte 0x28 16.--19. 1. "  [12|2] , "
hexmask.long.byte 0x28 24.--27. 1. "  [13|2] , "
hexmask.long.byte 0x2c 0.--3. 1. "  [14|2] , "
line.quad 0x2d "0xf33d"
hexmask.long.byte 0x2c 8.--11. 1. " Weight Table[0|3]         , "
hexmask.long.byte 0x2c 16.--19. 1. "  [1|3] , "
hexmask.long.byte 0x2c 24.--27. 1. "  [2|3] , "
hexmask.long.byte 0x30 0.--3. 1. "  [3|3] , "
hexmask.long.byte 0x30 8.--11. 1. "  [4|3] , "
hexmask.long.byte 0x30 16.--19. 1. "  [5|3] , "
hexmask.long.byte 0x30 24.--27. 1. "  [6|3] , "
hexmask.long.byte 0x34 0.--3. 1. "  [7|3] , "
hexmask.long.byte 0x34 8.--11. 1. "  [8|3] , "
hexmask.long.byte 0x34 16.--19. 1. "  [9|3] , "
hexmask.long.byte 0x34 24.--27. 1. "  [10|3] , "
hexmask.long.byte 0x38 0.--3. 1. "  [11|3] , "
hexmask.long.byte 0x38 8.--11. 1. "  [12|3] , "
hexmask.long.byte 0x38 16.--19. 1. "  [13|3] , "
hexmask.long.byte 0x38 24.--27. 1. "  [14|3] , "
line.quad 0x3c "0xf34c"
hexmask.long.byte 0x3c 0.--3. 1. " Weight Table[0|4]         , "
hexmask.long.byte 0x3c 8.--11. 1. "  [1|4] , "
hexmask.long.byte 0x3c 16.--19. 1. "  [2|4] , "
hexmask.long.byte 0x3c 24.--27. 1. "  [3|4] , "
hexmask.long.byte 0x40 0.--3. 1. "  [4|4] , "
hexmask.long.byte 0x40 8.--11. 1. "  [5|4] , "
hexmask.long.byte 0x40 16.--19. 1. "  [6|4] , "
hexmask.long.byte 0x40 24.--27. 1. "  [7|4] , "
hexmask.long.byte 0x44 0.--3. 1. "  [8|4] , "
hexmask.long.byte 0x44 8.--11. 1. "  [9|4] , "
hexmask.long.byte 0x44 16.--19. 1. "  [10|4] , "
hexmask.long.byte 0x44 24.--27. 1. "  [11|4] , "
hexmask.long.byte 0x48 0.--3. 1. "  [12|4] , "
hexmask.long.byte 0x48 8.--11. 1. "  [13|4] , "
hexmask.long.byte 0x48 16.--19. 1. "  [14|4] , "
line.quad 0x4b "0xf35b"
hexmask.long.byte 0x48 24.--27. 1. " Weight Table[0|5]         , "
hexmask.long.byte 0x4c 0.--3. 1. "  [1|5] , "
hexmask.long.byte 0x4c 8.--11. 1. "  [2|5] , "
hexmask.long.byte 0x4c 16.--19. 1. "  [3|5] , "
hexmask.long.byte 0x4c 24.--27. 1. "  [4|5] , "
hexmask.long.byte 0x50 0.--3. 1. "  [5|5] , "
hexmask.long.byte 0x50 8.--11. 1. "  [6|5] , "
hexmask.long.byte 0x50 16.--19. 1. "  [7|5] , "
hexmask.long.byte 0x50 24.--27. 1. "  [8|5] , "
hexmask.long.byte 0x54 0.--3. 1. "  [9|5] , "
hexmask.long.byte 0x54 8.--11. 1. "  [10|5] , "
hexmask.long.byte 0x54 16.--19. 1. "  [11|5] , "
hexmask.long.byte 0x54 24.--27. 1. "  [12|5] , "
hexmask.long.byte 0x58 0.--3. 1. "  [13|5] , "
hexmask.long.byte 0x58 8.--11. 1. "  [14|5] , "
line.quad 0x5a "0xf36a"
hexmask.long.byte 0x58 16.--19. 1. " Weight Table[0|6]         , "
hexmask.long.byte 0x58 24.--27. 1. "  [1|6] , "
hexmask.long.byte 0x5c 0.--3. 1. "  [2|6] , "
hexmask.long.byte 0x5c 8.--11. 1. "  [3|6] , "
hexmask.long.byte 0x5c 16.--19. 1. "  [4|6] , "
hexmask.long.byte 0x5c 24.--27. 1. "  [5|6] , "
hexmask.long.byte 0x60 0.--3. 1. "  [6|6] , "
hexmask.long.byte 0x60 8.--11. 1. "  [7|6] , "
hexmask.long.byte 0x60 16.--19. 1. "  [8|6] , "
hexmask.long.byte 0x60 24.--27. 1. "  [9|6] , "
hexmask.long.byte 0x64 0.--3. 1. "  [10|6] , "
hexmask.long.byte 0x64 8.--11. 1. "  [11|6] , "
hexmask.long.byte 0x64 16.--19. 1. "  [12|6] , "
hexmask.long.byte 0x64 24.--27. 1. "  [13|6] , "
hexmask.long.byte 0x68 0.--3. 1. "  [14|6] , "
line.quad 0x69 "0xf379"
hexmask.long.byte 0x68 8.--11. 1. " Weight Table[0|7]         , "
hexmask.long.byte 0x68 16.--19. 1. "  [1|7] , "
hexmask.long.byte 0x68 24.--27. 1. "  [2|7] , "
hexmask.long.byte 0x6c 0.--3. 1. "  [3|7] , "
hexmask.long.byte 0x6c 8.--11. 1. "  [4|7] , "
hexmask.long.byte 0x6c 16.--19. 1. "  [5|7] , "
hexmask.long.byte 0x6c 24.--27. 1. "  [6|7] , "
hexmask.long.byte 0x70 0.--3. 1. "  [7|7] , "
hexmask.long.byte 0x70 8.--11. 1. "  [8|7] , "
hexmask.long.byte 0x70 16.--19. 1. "  [9|7] , "
hexmask.long.byte 0x70 24.--27. 1. "  [10|7] , "
hexmask.long.byte 0x74 0.--3. 1. "  [11|7] , "
hexmask.long.byte 0x74 8.--11. 1. "  [12|7] , "
hexmask.long.byte 0x74 16.--19. 1. "  [13|7] , "
hexmask.long.byte 0x74 24.--27. 1. "  [14|7] , "
line.quad 0x78 "0xf388"
hexmask.long.byte 0x78 0.--3. 1. " Weight Table[0|8]         , "
hexmask.long.byte 0x78 8.--11. 1. "  [1|8] , "
hexmask.long.byte 0x78 16.--19. 1. "  [2|8] , "
hexmask.long.byte 0x78 24.--27. 1. "  [3|8] , "
hexmask.long.byte 0x7c 0.--3. 1. "  [4|8] , "
hexmask.long.byte 0x7c 8.--11. 1. "  [5|8] , "
hexmask.long.byte 0x7c 16.--19. 1. "  [6|8] , "
hexmask.long.byte 0x7c 24.--27. 1. "  [7|8] , "
hexmask.long.byte 0x80 0.--3. 1. "  [8|8] , "
hexmask.long.byte 0x80 8.--11. 1. "  [9|8] , "
hexmask.long.byte 0x80 16.--19. 1. "  [10|8] , "
hexmask.long.byte 0x80 24.--27. 1. "  [11|8] , "
hexmask.long.byte 0x84 0.--3. 1. "  [12|8] , "
hexmask.long.byte 0x84 8.--11. 1. "  [13|8] , "
hexmask.long.byte 0x84 16.--19. 1. "  [14|8] , "
line.quad 0x87 "0xf397"
hexmask.long.byte 0x84 24.--27. 1. " Weight Table[0|9]         , "
hexmask.long.byte 0x88 0.--3. 1. "  [1|9] , "
hexmask.long.byte 0x88 8.--11. 1. "  [2|9] , "
hexmask.long.byte 0x88 16.--19. 1. "  [3|9] , "
hexmask.long.byte 0x88 24.--27. 1. "  [4|9] , "
hexmask.long.byte 0x8c 0.--3. 1. "  [5|9] , "
hexmask.long.byte 0x8c 8.--11. 1. "  [6|9] , "
hexmask.long.byte 0x8c 16.--19. 1. "  [7|9] , "
hexmask.long.byte 0x8c 24.--27. 1. "  [8|9] , "
hexmask.long.byte 0x90 0.--3. 1. "  [9|9] , "
hexmask.long.byte 0x90 8.--11. 1. "  [10|9] , "
hexmask.long.byte 0x90 16.--19. 1. "  [11|9] , "
hexmask.long.byte 0x90 24.--27. 1. "  [12|9] , "
hexmask.long.byte 0x94 0.--3. 1. "  [13|9] , "
hexmask.long.byte 0x94 8.--11. 1. "  [14|9] , "
line.quad 0x96 "0xf3a6"
hexmask.long.byte 0x94 16.--19. 1. " Weight Table[0|10]        , "
hexmask.long.byte 0x94 24.--27. 1. "  [1|10] , "
hexmask.long.byte 0x98 0.--3. 1. "  [2|10] , "
hexmask.long.byte 0x98 8.--11. 1. "  [3|10] , "
hexmask.long.byte 0x98 16.--19. 1. "  [4|10] , "
hexmask.long.byte 0x98 24.--27. 1. "  [5|10] , "
hexmask.long.byte 0x9c 0.--3. 1. "  [6|10] , "
hexmask.long.byte 0x9c 8.--11. 1. "  [7|10] , "
hexmask.long.byte 0x9c 16.--19. 1. "  [8|10] , "
hexmask.long.byte 0x9c 24.--27. 1. "  [9|10] , "
hexmask.long.byte 0xa0 0.--3. 1. "  [10|10] , "
hexmask.long.byte 0xa0 8.--11. 1. "  [11|10] , "
hexmask.long.byte 0xa0 16.--19. 1. "  [12|10] , "
hexmask.long.byte 0xa0 24.--27. 1. "  [13|10] , "
hexmask.long.byte 0xa4 0.--3. 1. "  [14|10] , "
line.quad 0xa5 "0xf3b5"
hexmask.long.byte 0xa4 8.--11. 1. " Weight Table[0|11]        , "
hexmask.long.byte 0xa4 16.--19. 1. "  [1|11] , "
hexmask.long.byte 0xa4 24.--27. 1. "  [2|11] , "
hexmask.long.byte 0xa8 0.--3. 1. "  [3|11] , "
hexmask.long.byte 0xa8 8.--11. 1. "  [4|11] , "
hexmask.long.byte 0xa8 16.--19. 1. "  [5|11] , "
hexmask.long.byte 0xa8 24.--27. 1. "  [6|11] , "
hexmask.long.byte 0xac 0.--3. 1. "  [7|11] , "
hexmask.long.byte 0xac 8.--11. 1. "  [8|11] , "
hexmask.long.byte 0xac 16.--19. 1. "  [9|11] , "
hexmask.long.byte 0xac 24.--27. 1. "  [10|11] , "
hexmask.long.byte 0xb0 0.--3. 1. "  [11|11] , "
hexmask.long.byte 0xb0 8.--11. 1. "  [12|11] , "
hexmask.long.byte 0xb0 16.--19. 1. "  [13|11] , "
hexmask.long.byte 0xb0 24.--27. 1. "  [14|11] , "
line.quad 0xb4 "0xf3c4"
hexmask.long.byte 0xb4 0.--3. 1. " Weight Table[0|12]        , "
hexmask.long.byte 0xb4 8.--11. 1. "  [1|12] , "
hexmask.long.byte 0xb4 16.--19. 1. "  [2|12] , "
hexmask.long.byte 0xb4 24.--27. 1. "  [3|12] , "
hexmask.long.byte 0xb8 0.--3. 1. "  [4|12] , "
hexmask.long.byte 0xb8 8.--11. 1. "  [5|12] , "
hexmask.long.byte 0xb8 16.--19. 1. "  [6|12] , "
hexmask.long.byte 0xb8 24.--27. 1. "  [7|12] , "
hexmask.long.byte 0xbc 0.--3. 1. "  [8|12] , "
hexmask.long.byte 0xbc 8.--11. 1. "  [9|12] , "
hexmask.long.byte 0xbc 16.--19. 1. "  [10|12] , "
hexmask.long.byte 0xbc 24.--27. 1. "  [11|12] , "
hexmask.long.byte 0xc0 0.--3. 1. "  [12|12] , "
hexmask.long.byte 0xc0 8.--11. 1. "  [13|12] , "
hexmask.long.byte 0xc0 16.--19. 1. "  [14|12] , "
line.quad 0xc3 "0xf3d3"
hexmask.long.byte 0xc0 24.--27. 1. " Weight Table[0|13]        , "
hexmask.long.byte 0xc4 0.--3. 1. "  [1|13] , "
hexmask.long.byte 0xc4 8.--11. 1. "  [2|13] , "
hexmask.long.byte 0xc4 16.--19. 1. "  [3|13] , "
hexmask.long.byte 0xc4 24.--27. 1. "  [4|13] , "
hexmask.long.byte 0xc8 0.--3. 1. "  [5|13] , "
hexmask.long.byte 0xc8 8.--11. 1. "  [6|13] , "
hexmask.long.byte 0xc8 16.--19. 1. "  [7|13] , "
hexmask.long.byte 0xc8 24.--27. 1. "  [8|13] , "
hexmask.long.byte 0xcc 0.--3. 1. "  [9|13] , "
hexmask.long.byte 0xcc 8.--11. 1. "  [10|13] , "
hexmask.long.byte 0xcc 16.--19. 1. "  [11|13] , "
hexmask.long.byte 0xcc 24.--27. 1. "  [12|13] , "
hexmask.long.byte 0xd0 0.--3. 1. "  [13|13] , "
hexmask.long.byte 0xd0 8.--11. 1. "  [14|13] , "
line.quad 0xd2 "0xf3e2"
hexmask.long.byte 0xd0 16.--19. 1. " Weight Table[0|14]        , "
hexmask.long.byte 0xd0 24.--27. 1. "  [1|14] , "
hexmask.long.byte 0xd4 0.--3. 1. "  [2|14] , "
hexmask.long.byte 0xd4 8.--11. 1. "  [3|14] , "
hexmask.long.byte 0xd4 16.--19. 1. "  [4|14] , "
hexmask.long.byte 0xd4 24.--27. 1. "  [5|14] , "
hexmask.long.byte 0xd8 0.--3. 1. "  [6|14] , "
hexmask.long.byte 0xd8 8.--11. 1. "  [7|14] , "
hexmask.long.byte 0xd8 16.--19. 1. "  [8|14] , "
hexmask.long.byte 0xd8 24.--27. 1. "  [9|14] , "
hexmask.long.byte 0xdc 0.--3. 1. "  [10|14] , "
hexmask.long.byte 0xdc 8.--11. 1. "  [11|14] , "
hexmask.long.byte 0xdc 16.--19. 1. "  [12|14] , "
hexmask.long.byte 0xdc 24.--27. 1. "  [13|14] , "
hexmask.long.byte 0xe0 0.--3. 1. "  [14|14] , "
TREE.END
TREE "Metering Hist 3"
group.long 0xf400++0x3
line.long 0x00 "0xf400"
hexmask.long.byte 0x00 0.--2. 1. " skip x  ,Histogram decimation in horizontal direction: 0=every 2nd pixel; 1=every 3rd pixel; 2=every 4th pixel; 3=every 5th pixel; 4=every 8th pixel ; 5+=every 9th pixel"
hexmask.long.byte 0x00 4.--6. 1. " skip y  ,Histogram decimation in vertical direction: 0=every pixel; 1=every 2nd pixel; 2=every 3rd pixel; 3=every 4th pixel; 4=every 5th pixel; 5=every 8th pixel ; 6+=every 9th pixel"
textline "                 "
bitfld.long 0x00 3. " offset x  , 0= start from the first column;  1=start from second column  "
bitfld.long 0x00 7. " offset y  , 0= start from the first row; 1= start from second row  "
hexmask.long.byte 0x00 8.--10. 1. " Plane mode  ,Plane separation mode (0=Collect all the planes in one histogram, 1=Collect 4 Bayer planes into 4 separate banks, 2=Collect every pixel of 4 Bayer planes into 4 separate banks, 3=Reserved 3, 4=Collect odd  x odd  y plane to bank 0, rest to bank 1, 5=Collect even x odd  y plane to bank 0, rest to bank 1, 6=Collect odd  x even y plane to bank 0, rest to bank 1, 7=Collect even x even y plane to bank 0, rest to bank 1)"
textline "                 "
bitfld.long 0x00 12. " Radial shading enable  , Enable radial shading correction.  "
hexmask.long.byte 0x00 16.--23. 1. " Nodes Used Horiz  ,Number of active zones horizontally for AE stats collection"
hexmask.long.byte 0x00 24.--31. 1. " Nodes Used Vert  ,Number of active zones vertically for AE stats collection"
group.long 0xf404++0x3
line.long 0x00 "0xf404"
hexmask.long.byte 0x00 0.--3. 1. " scale bottom  ,scale of bottom half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
hexmask.long.byte 0x00 4.--7. 1. " scale top  ,scale of top half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
rgroup.long 0xf408++0x3
line.long 0x00 "0xf408"
hexmask.long.long 0x00 0.--31. 1. " Total Pixels  ,Total number of pixels processed (skip x and skip y are taken into account)"
rgroup.long 0xf40c++0x3
line.long 0x00 "0xf40c"
hexmask.long.long 0x00 0.--31. 1. " Counted Pixels  ,Number of pixels accumulated (with nonzero weight)"
group.long 0x0++0x10
group.long 0x0++0x10
group.long 0xf430++0x3
line.long 0x00 "0xf430"
hexmask.long.word 0x00 0.--11. 1. " Gain 00  ,Multiplier for color channel 00 (R)"
group.long 0xf434++0x3
line.long 0x00 "0xf434"
hexmask.long.word 0x00 0.--11. 1. " Gain 01  ,Multiplier for color channel 01 (Gr)"
group.long 0xf438++0x3
line.long 0x00 "0xf438"
hexmask.long.word 0x00 0.--11. 1. " Gain 10  ,Multiplier for color channel 10 (Gb)"
group.long 0xf43c++0x3
line.long 0x00 "0xf43c"
hexmask.long.word 0x00 0.--11. 1. " Gain 11  ,Multiplier for color channel 11 (B)"
group.long 0xf440++0x3
line.long 0x00 "0xf440"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xf444++0x3
line.long 0x00 "0xf444"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xf448++0x3
line.long 0x00 "0xf448"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xf44c++0x3
line.long 0x00 "0xf44c"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
group.long 0xf450++0x3
line.long 0x00 "0xf450"
hexmask.long.word 0x00 0.--15. 1. " Center X  ,Center x coordinate of the shading map"
group.long 0xf454++0x3
line.long 0x00 "0xf454"
hexmask.long.word 0x00 0.--15. 1. " Center Y  ,Center y coordinate of the shading map"
group.long 0xf458++0x3
line.long 0x00 "0xf458"
hexmask.long.word 0x00 0.--15. 1. " Off Center multx  ,Normalizing X factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xf45c++0x3
line.long 0x00 "0xf45c"
hexmask.long.word 0x00 0.--15. 1. " Off Center multy  ,Normalizing Y factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xf460++0x3
line.long 0x00 "0xf460"
hexmask.long.word 0x00 0.--15. 1. " Active Width  ,Active video width in pixels"
group.long 0xf464++0x3
line.long 0x00 "0xf464"
hexmask.long.word 0x00 0.--15. 1. " Active Height  ,Active video height in lines"
group.long 0xf468++0x3
line.long 0x00 "0xf468"
hexmask.long.byte 0x00 0.--1. 1. " RGGB start  ,Starting color of the rggb pattern (0=R Gr   Gb B, 1=Gr R   B Gb, 2=Gb B   R Gr, 3=B Gb   Gr R)"
hexmask.long.byte 0x00 4.--5. 1. " CFA pattern  ,Pattern select: (0=RGGB, 1=RCCC, 2=RIrGB, 3=RGIrB)"
group.long 0xf490++0xe5
line.quad 0x00 "0xf490"
hexmask.long.byte 0x0 0.--3. 1. " Weight Table[0|0]         , "
hexmask.long.byte 0x0 8.--11. 1. "  [1|0] , "
hexmask.long.byte 0x0 16.--19. 1. "  [2|0] , "
hexmask.long.byte 0x0 24.--27. 1. "  [3|0] , "
hexmask.long.byte 0x4 0.--3. 1. "  [4|0] , "
hexmask.long.byte 0x4 8.--11. 1. "  [5|0] , "
hexmask.long.byte 0x4 16.--19. 1. "  [6|0] , "
hexmask.long.byte 0x4 24.--27. 1. "  [7|0] , "
hexmask.long.byte 0x8 0.--3. 1. "  [8|0] , "
hexmask.long.byte 0x8 8.--11. 1. "  [9|0] , "
hexmask.long.byte 0x8 16.--19. 1. "  [10|0] , "
hexmask.long.byte 0x8 24.--27. 1. "  [11|0] , "
hexmask.long.byte 0xc 0.--3. 1. "  [12|0] , "
hexmask.long.byte 0xc 8.--11. 1. "  [13|0] , "
hexmask.long.byte 0xc 16.--19. 1. "  [14|0] , "
line.quad 0x0f "0xf49f"
hexmask.long.byte 0xc 24.--27. 1. " Weight Table[0|1]         , "
hexmask.long.byte 0x10 0.--3. 1. "  [1|1] , "
hexmask.long.byte 0x10 8.--11. 1. "  [2|1] , "
hexmask.long.byte 0x10 16.--19. 1. "  [3|1] , "
hexmask.long.byte 0x10 24.--27. 1. "  [4|1] , "
hexmask.long.byte 0x14 0.--3. 1. "  [5|1] , "
hexmask.long.byte 0x14 8.--11. 1. "  [6|1] , "
hexmask.long.byte 0x14 16.--19. 1. "  [7|1] , "
hexmask.long.byte 0x14 24.--27. 1. "  [8|1] , "
hexmask.long.byte 0x18 0.--3. 1. "  [9|1] , "
hexmask.long.byte 0x18 8.--11. 1. "  [10|1] , "
hexmask.long.byte 0x18 16.--19. 1. "  [11|1] , "
hexmask.long.byte 0x18 24.--27. 1. "  [12|1] , "
hexmask.long.byte 0x1c 0.--3. 1. "  [13|1] , "
hexmask.long.byte 0x1c 8.--11. 1. "  [14|1] , "
line.quad 0x1e "0xf4ae"
hexmask.long.byte 0x1c 16.--19. 1. " Weight Table[0|2]         , "
hexmask.long.byte 0x1c 24.--27. 1. "  [1|2] , "
hexmask.long.byte 0x20 0.--3. 1. "  [2|2] , "
hexmask.long.byte 0x20 8.--11. 1. "  [3|2] , "
hexmask.long.byte 0x20 16.--19. 1. "  [4|2] , "
hexmask.long.byte 0x20 24.--27. 1. "  [5|2] , "
hexmask.long.byte 0x24 0.--3. 1. "  [6|2] , "
hexmask.long.byte 0x24 8.--11. 1. "  [7|2] , "
hexmask.long.byte 0x24 16.--19. 1. "  [8|2] , "
hexmask.long.byte 0x24 24.--27. 1. "  [9|2] , "
hexmask.long.byte 0x28 0.--3. 1. "  [10|2] , "
hexmask.long.byte 0x28 8.--11. 1. "  [11|2] , "
hexmask.long.byte 0x28 16.--19. 1. "  [12|2] , "
hexmask.long.byte 0x28 24.--27. 1. "  [13|2] , "
hexmask.long.byte 0x2c 0.--3. 1. "  [14|2] , "
line.quad 0x2d "0xf4bd"
hexmask.long.byte 0x2c 8.--11. 1. " Weight Table[0|3]         , "
hexmask.long.byte 0x2c 16.--19. 1. "  [1|3] , "
hexmask.long.byte 0x2c 24.--27. 1. "  [2|3] , "
hexmask.long.byte 0x30 0.--3. 1. "  [3|3] , "
hexmask.long.byte 0x30 8.--11. 1. "  [4|3] , "
hexmask.long.byte 0x30 16.--19. 1. "  [5|3] , "
hexmask.long.byte 0x30 24.--27. 1. "  [6|3] , "
hexmask.long.byte 0x34 0.--3. 1. "  [7|3] , "
hexmask.long.byte 0x34 8.--11. 1. "  [8|3] , "
hexmask.long.byte 0x34 16.--19. 1. "  [9|3] , "
hexmask.long.byte 0x34 24.--27. 1. "  [10|3] , "
hexmask.long.byte 0x38 0.--3. 1. "  [11|3] , "
hexmask.long.byte 0x38 8.--11. 1. "  [12|3] , "
hexmask.long.byte 0x38 16.--19. 1. "  [13|3] , "
hexmask.long.byte 0x38 24.--27. 1. "  [14|3] , "
line.quad 0x3c "0xf4cc"
hexmask.long.byte 0x3c 0.--3. 1. " Weight Table[0|4]         , "
hexmask.long.byte 0x3c 8.--11. 1. "  [1|4] , "
hexmask.long.byte 0x3c 16.--19. 1. "  [2|4] , "
hexmask.long.byte 0x3c 24.--27. 1. "  [3|4] , "
hexmask.long.byte 0x40 0.--3. 1. "  [4|4] , "
hexmask.long.byte 0x40 8.--11. 1. "  [5|4] , "
hexmask.long.byte 0x40 16.--19. 1. "  [6|4] , "
hexmask.long.byte 0x40 24.--27. 1. "  [7|4] , "
hexmask.long.byte 0x44 0.--3. 1. "  [8|4] , "
hexmask.long.byte 0x44 8.--11. 1. "  [9|4] , "
hexmask.long.byte 0x44 16.--19. 1. "  [10|4] , "
hexmask.long.byte 0x44 24.--27. 1. "  [11|4] , "
hexmask.long.byte 0x48 0.--3. 1. "  [12|4] , "
hexmask.long.byte 0x48 8.--11. 1. "  [13|4] , "
hexmask.long.byte 0x48 16.--19. 1. "  [14|4] , "
line.quad 0x4b "0xf4db"
hexmask.long.byte 0x48 24.--27. 1. " Weight Table[0|5]         , "
hexmask.long.byte 0x4c 0.--3. 1. "  [1|5] , "
hexmask.long.byte 0x4c 8.--11. 1. "  [2|5] , "
hexmask.long.byte 0x4c 16.--19. 1. "  [3|5] , "
hexmask.long.byte 0x4c 24.--27. 1. "  [4|5] , "
hexmask.long.byte 0x50 0.--3. 1. "  [5|5] , "
hexmask.long.byte 0x50 8.--11. 1. "  [6|5] , "
hexmask.long.byte 0x50 16.--19. 1. "  [7|5] , "
hexmask.long.byte 0x50 24.--27. 1. "  [8|5] , "
hexmask.long.byte 0x54 0.--3. 1. "  [9|5] , "
hexmask.long.byte 0x54 8.--11. 1. "  [10|5] , "
hexmask.long.byte 0x54 16.--19. 1. "  [11|5] , "
hexmask.long.byte 0x54 24.--27. 1. "  [12|5] , "
hexmask.long.byte 0x58 0.--3. 1. "  [13|5] , "
hexmask.long.byte 0x58 8.--11. 1. "  [14|5] , "
line.quad 0x5a "0xf4ea"
hexmask.long.byte 0x58 16.--19. 1. " Weight Table[0|6]         , "
hexmask.long.byte 0x58 24.--27. 1. "  [1|6] , "
hexmask.long.byte 0x5c 0.--3. 1. "  [2|6] , "
hexmask.long.byte 0x5c 8.--11. 1. "  [3|6] , "
hexmask.long.byte 0x5c 16.--19. 1. "  [4|6] , "
hexmask.long.byte 0x5c 24.--27. 1. "  [5|6] , "
hexmask.long.byte 0x60 0.--3. 1. "  [6|6] , "
hexmask.long.byte 0x60 8.--11. 1. "  [7|6] , "
hexmask.long.byte 0x60 16.--19. 1. "  [8|6] , "
hexmask.long.byte 0x60 24.--27. 1. "  [9|6] , "
hexmask.long.byte 0x64 0.--3. 1. "  [10|6] , "
hexmask.long.byte 0x64 8.--11. 1. "  [11|6] , "
hexmask.long.byte 0x64 16.--19. 1. "  [12|6] , "
hexmask.long.byte 0x64 24.--27. 1. "  [13|6] , "
hexmask.long.byte 0x68 0.--3. 1. "  [14|6] , "
line.quad 0x69 "0xf4f9"
hexmask.long.byte 0x68 8.--11. 1. " Weight Table[0|7]         , "
hexmask.long.byte 0x68 16.--19. 1. "  [1|7] , "
hexmask.long.byte 0x68 24.--27. 1. "  [2|7] , "
hexmask.long.byte 0x6c 0.--3. 1. "  [3|7] , "
hexmask.long.byte 0x6c 8.--11. 1. "  [4|7] , "
hexmask.long.byte 0x6c 16.--19. 1. "  [5|7] , "
hexmask.long.byte 0x6c 24.--27. 1. "  [6|7] , "
hexmask.long.byte 0x70 0.--3. 1. "  [7|7] , "
hexmask.long.byte 0x70 8.--11. 1. "  [8|7] , "
hexmask.long.byte 0x70 16.--19. 1. "  [9|7] , "
hexmask.long.byte 0x70 24.--27. 1. "  [10|7] , "
hexmask.long.byte 0x74 0.--3. 1. "  [11|7] , "
hexmask.long.byte 0x74 8.--11. 1. "  [12|7] , "
hexmask.long.byte 0x74 16.--19. 1. "  [13|7] , "
hexmask.long.byte 0x74 24.--27. 1. "  [14|7] , "
line.quad 0x78 "0xf508"
hexmask.long.byte 0x78 0.--3. 1. " Weight Table[0|8]         , "
hexmask.long.byte 0x78 8.--11. 1. "  [1|8] , "
hexmask.long.byte 0x78 16.--19. 1. "  [2|8] , "
hexmask.long.byte 0x78 24.--27. 1. "  [3|8] , "
hexmask.long.byte 0x7c 0.--3. 1. "  [4|8] , "
hexmask.long.byte 0x7c 8.--11. 1. "  [5|8] , "
hexmask.long.byte 0x7c 16.--19. 1. "  [6|8] , "
hexmask.long.byte 0x7c 24.--27. 1. "  [7|8] , "
hexmask.long.byte 0x80 0.--3. 1. "  [8|8] , "
hexmask.long.byte 0x80 8.--11. 1. "  [9|8] , "
hexmask.long.byte 0x80 16.--19. 1. "  [10|8] , "
hexmask.long.byte 0x80 24.--27. 1. "  [11|8] , "
hexmask.long.byte 0x84 0.--3. 1. "  [12|8] , "
hexmask.long.byte 0x84 8.--11. 1. "  [13|8] , "
hexmask.long.byte 0x84 16.--19. 1. "  [14|8] , "
line.quad 0x87 "0xf517"
hexmask.long.byte 0x84 24.--27. 1. " Weight Table[0|9]         , "
hexmask.long.byte 0x88 0.--3. 1. "  [1|9] , "
hexmask.long.byte 0x88 8.--11. 1. "  [2|9] , "
hexmask.long.byte 0x88 16.--19. 1. "  [3|9] , "
hexmask.long.byte 0x88 24.--27. 1. "  [4|9] , "
hexmask.long.byte 0x8c 0.--3. 1. "  [5|9] , "
hexmask.long.byte 0x8c 8.--11. 1. "  [6|9] , "
hexmask.long.byte 0x8c 16.--19. 1. "  [7|9] , "
hexmask.long.byte 0x8c 24.--27. 1. "  [8|9] , "
hexmask.long.byte 0x90 0.--3. 1. "  [9|9] , "
hexmask.long.byte 0x90 8.--11. 1. "  [10|9] , "
hexmask.long.byte 0x90 16.--19. 1. "  [11|9] , "
hexmask.long.byte 0x90 24.--27. 1. "  [12|9] , "
hexmask.long.byte 0x94 0.--3. 1. "  [13|9] , "
hexmask.long.byte 0x94 8.--11. 1. "  [14|9] , "
line.quad 0x96 "0xf526"
hexmask.long.byte 0x94 16.--19. 1. " Weight Table[0|10]        , "
hexmask.long.byte 0x94 24.--27. 1. "  [1|10] , "
hexmask.long.byte 0x98 0.--3. 1. "  [2|10] , "
hexmask.long.byte 0x98 8.--11. 1. "  [3|10] , "
hexmask.long.byte 0x98 16.--19. 1. "  [4|10] , "
hexmask.long.byte 0x98 24.--27. 1. "  [5|10] , "
hexmask.long.byte 0x9c 0.--3. 1. "  [6|10] , "
hexmask.long.byte 0x9c 8.--11. 1. "  [7|10] , "
hexmask.long.byte 0x9c 16.--19. 1. "  [8|10] , "
hexmask.long.byte 0x9c 24.--27. 1. "  [9|10] , "
hexmask.long.byte 0xa0 0.--3. 1. "  [10|10] , "
hexmask.long.byte 0xa0 8.--11. 1. "  [11|10] , "
hexmask.long.byte 0xa0 16.--19. 1. "  [12|10] , "
hexmask.long.byte 0xa0 24.--27. 1. "  [13|10] , "
hexmask.long.byte 0xa4 0.--3. 1. "  [14|10] , "
line.quad 0xa5 "0xf535"
hexmask.long.byte 0xa4 8.--11. 1. " Weight Table[0|11]        , "
hexmask.long.byte 0xa4 16.--19. 1. "  [1|11] , "
hexmask.long.byte 0xa4 24.--27. 1. "  [2|11] , "
hexmask.long.byte 0xa8 0.--3. 1. "  [3|11] , "
hexmask.long.byte 0xa8 8.--11. 1. "  [4|11] , "
hexmask.long.byte 0xa8 16.--19. 1. "  [5|11] , "
hexmask.long.byte 0xa8 24.--27. 1. "  [6|11] , "
hexmask.long.byte 0xac 0.--3. 1. "  [7|11] , "
hexmask.long.byte 0xac 8.--11. 1. "  [8|11] , "
hexmask.long.byte 0xac 16.--19. 1. "  [9|11] , "
hexmask.long.byte 0xac 24.--27. 1. "  [10|11] , "
hexmask.long.byte 0xb0 0.--3. 1. "  [11|11] , "
hexmask.long.byte 0xb0 8.--11. 1. "  [12|11] , "
hexmask.long.byte 0xb0 16.--19. 1. "  [13|11] , "
hexmask.long.byte 0xb0 24.--27. 1. "  [14|11] , "
line.quad 0xb4 "0xf544"
hexmask.long.byte 0xb4 0.--3. 1. " Weight Table[0|12]        , "
hexmask.long.byte 0xb4 8.--11. 1. "  [1|12] , "
hexmask.long.byte 0xb4 16.--19. 1. "  [2|12] , "
hexmask.long.byte 0xb4 24.--27. 1. "  [3|12] , "
hexmask.long.byte 0xb8 0.--3. 1. "  [4|12] , "
hexmask.long.byte 0xb8 8.--11. 1. "  [5|12] , "
hexmask.long.byte 0xb8 16.--19. 1. "  [6|12] , "
hexmask.long.byte 0xb8 24.--27. 1. "  [7|12] , "
hexmask.long.byte 0xbc 0.--3. 1. "  [8|12] , "
hexmask.long.byte 0xbc 8.--11. 1. "  [9|12] , "
hexmask.long.byte 0xbc 16.--19. 1. "  [10|12] , "
hexmask.long.byte 0xbc 24.--27. 1. "  [11|12] , "
hexmask.long.byte 0xc0 0.--3. 1. "  [12|12] , "
hexmask.long.byte 0xc0 8.--11. 1. "  [13|12] , "
hexmask.long.byte 0xc0 16.--19. 1. "  [14|12] , "
line.quad 0xc3 "0xf553"
hexmask.long.byte 0xc0 24.--27. 1. " Weight Table[0|13]        , "
hexmask.long.byte 0xc4 0.--3. 1. "  [1|13] , "
hexmask.long.byte 0xc4 8.--11. 1. "  [2|13] , "
hexmask.long.byte 0xc4 16.--19. 1. "  [3|13] , "
hexmask.long.byte 0xc4 24.--27. 1. "  [4|13] , "
hexmask.long.byte 0xc8 0.--3. 1. "  [5|13] , "
hexmask.long.byte 0xc8 8.--11. 1. "  [6|13] , "
hexmask.long.byte 0xc8 16.--19. 1. "  [7|13] , "
hexmask.long.byte 0xc8 24.--27. 1. "  [8|13] , "
hexmask.long.byte 0xcc 0.--3. 1. "  [9|13] , "
hexmask.long.byte 0xcc 8.--11. 1. "  [10|13] , "
hexmask.long.byte 0xcc 16.--19. 1. "  [11|13] , "
hexmask.long.byte 0xcc 24.--27. 1. "  [12|13] , "
hexmask.long.byte 0xd0 0.--3. 1. "  [13|13] , "
hexmask.long.byte 0xd0 8.--11. 1. "  [14|13] , "
line.quad 0xd2 "0xf562"
hexmask.long.byte 0xd0 16.--19. 1. " Weight Table[0|14]        , "
hexmask.long.byte 0xd0 24.--27. 1. "  [1|14] , "
hexmask.long.byte 0xd4 0.--3. 1. "  [2|14] , "
hexmask.long.byte 0xd4 8.--11. 1. "  [3|14] , "
hexmask.long.byte 0xd4 16.--19. 1. "  [4|14] , "
hexmask.long.byte 0xd4 24.--27. 1. "  [5|14] , "
hexmask.long.byte 0xd8 0.--3. 1. "  [6|14] , "
hexmask.long.byte 0xd8 8.--11. 1. "  [7|14] , "
hexmask.long.byte 0xd8 16.--19. 1. "  [8|14] , "
hexmask.long.byte 0xd8 24.--27. 1. "  [9|14] , "
hexmask.long.byte 0xdc 0.--3. 1. "  [10|14] , "
hexmask.long.byte 0xdc 8.--11. 1. "  [11|14] , "
hexmask.long.byte 0xdc 16.--19. 1. "  [12|14] , "
hexmask.long.byte 0xdc 24.--27. 1. "  [13|14] , "
hexmask.long.byte 0xe0 0.--3. 1. "  [14|14] , "
TREE.END
TREE "Metering Hist 4"
group.long 0xf580++0x3
line.long 0x00 "0xf580"
hexmask.long.byte 0x00 0.--2. 1. " skip x  ,Histogram decimation in horizontal direction: 0=every 2nd pixel; 1=every 3rd pixel; 2=every 4th pixel; 3=every 5th pixel; 4=every 8th pixel ; 5+=every 9th pixel"
hexmask.long.byte 0x00 4.--6. 1. " skip y  ,Histogram decimation in vertical direction: 0=every pixel; 1=every 2nd pixel; 2=every 3rd pixel; 3=every 4th pixel; 4=every 5th pixel; 5=every 8th pixel ; 6+=every 9th pixel"
textline "                 "
bitfld.long 0x00 3. " offset x  , 0= start from the first column;  1=start from second column  "
bitfld.long 0x00 7. " offset y  , 0= start from the first row; 1= start from second row  "
hexmask.long.byte 0x00 8.--10. 1. " Plane mode  ,Plane separation mode (0=Collect all the planes in one histogram, 1=Collect 4 Bayer planes into 4 separate banks, 2=Collect every pixel of 4 Bayer planes into 4 separate banks, 3=Reserved 3, 4=Collect odd  x odd  y plane to bank 0, rest to bank 1, 5=Collect even x odd  y plane to bank 0, rest to bank 1, 6=Collect odd  x even y plane to bank 0, rest to bank 1, 7=Collect even x even y plane to bank 0, rest to bank 1)"
textline "                 "
bitfld.long 0x00 12. " Radial shading enable  , Enable radial shading correction.  "
hexmask.long.byte 0x00 16.--23. 1. " Nodes Used Horiz  ,Number of active zones horizontally for AE stats collection"
hexmask.long.byte 0x00 24.--31. 1. " Nodes Used Vert  ,Number of active zones vertically for AE stats collection"
group.long 0xf584++0x3
line.long 0x00 "0xf584"
hexmask.long.byte 0x00 0.--3. 1. " scale bottom  ,scale of bottom half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
hexmask.long.byte 0x00 4.--7. 1. " scale top  ,scale of top half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
rgroup.long 0xf588++0x3
line.long 0x00 "0xf588"
hexmask.long.long 0x00 0.--31. 1. " Total Pixels  ,Total number of pixels processed (skip x and skip y are taken into account)"
rgroup.long 0xf58c++0x3
line.long 0x00 "0xf58c"
hexmask.long.long 0x00 0.--31. 1. " Counted Pixels  ,Number of pixels accumulated (with nonzero weight)"
group.long 0x0++0x10
group.long 0x0++0x10
group.long 0xf5b0++0x3
line.long 0x00 "0xf5b0"
hexmask.long.word 0x00 0.--11. 1. " Gain 00  ,Multiplier for color channel 00 (R)"
group.long 0xf5b4++0x3
line.long 0x00 "0xf5b4"
hexmask.long.word 0x00 0.--11. 1. " Gain 01  ,Multiplier for color channel 01 (Gr)"
group.long 0xf5b8++0x3
line.long 0x00 "0xf5b8"
hexmask.long.word 0x00 0.--11. 1. " Gain 10  ,Multiplier for color channel 10 (Gb)"
group.long 0xf5bc++0x3
line.long 0x00 "0xf5bc"
hexmask.long.word 0x00 0.--11. 1. " Gain 11  ,Multiplier for color channel 11 (B)"
group.long 0xf5c0++0x3
line.long 0x00 "0xf5c0"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xf5c4++0x3
line.long 0x00 "0xf5c4"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xf5c8++0x3
line.long 0x00 "0xf5c8"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xf5cc++0x3
line.long 0x00 "0xf5cc"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
group.long 0xf5d0++0x3
line.long 0x00 "0xf5d0"
hexmask.long.word 0x00 0.--15. 1. " Center X  ,Center x coordinate of the shading map"
group.long 0xf5d4++0x3
line.long 0x00 "0xf5d4"
hexmask.long.word 0x00 0.--15. 1. " Center Y  ,Center y coordinate of the shading map"
group.long 0xf5d8++0x3
line.long 0x00 "0xf5d8"
hexmask.long.word 0x00 0.--15. 1. " Off Center multx  ,Normalizing X factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xf5dc++0x3
line.long 0x00 "0xf5dc"
hexmask.long.word 0x00 0.--15. 1. " Off Center multy  ,Normalizing Y factor which scales the radial table to the edge of the image.         Calculated as 2^31/R^2 where R is the furthest distance from the center coordinate to the edge of the image in pixels."
group.long 0xf5e0++0x3
line.long 0x00 "0xf5e0"
hexmask.long.word 0x00 0.--15. 1. " Active Width  ,Active video width in pixels"
group.long 0xf5e4++0x3
line.long 0x00 "0xf5e4"
hexmask.long.word 0x00 0.--15. 1. " Active Height  ,Active video height in lines"
group.long 0xf5e8++0x3
line.long 0x00 "0xf5e8"
hexmask.long.byte 0x00 0.--1. 1. " RGGB start  ,Starting color of the rggb pattern (0=R Gr   Gb B, 1=Gr R   B Gb, 2=Gb B   R Gr, 3=B Gb   Gr R)"
hexmask.long.byte 0x00 4.--5. 1. " CFA pattern  ,Pattern select: (0=RGGB, 1=RCCC, 2=RIrGB, 3=RGIrB)"
group.long 0xf610++0xe5
line.quad 0x00 "0xf610"
hexmask.long.byte 0x0 0.--3. 1. " Weight Table[0|0]         , "
hexmask.long.byte 0x0 8.--11. 1. "  [1|0] , "
hexmask.long.byte 0x0 16.--19. 1. "  [2|0] , "
hexmask.long.byte 0x0 24.--27. 1. "  [3|0] , "
hexmask.long.byte 0x4 0.--3. 1. "  [4|0] , "
hexmask.long.byte 0x4 8.--11. 1. "  [5|0] , "
hexmask.long.byte 0x4 16.--19. 1. "  [6|0] , "
hexmask.long.byte 0x4 24.--27. 1. "  [7|0] , "
hexmask.long.byte 0x8 0.--3. 1. "  [8|0] , "
hexmask.long.byte 0x8 8.--11. 1. "  [9|0] , "
hexmask.long.byte 0x8 16.--19. 1. "  [10|0] , "
hexmask.long.byte 0x8 24.--27. 1. "  [11|0] , "
hexmask.long.byte 0xc 0.--3. 1. "  [12|0] , "
hexmask.long.byte 0xc 8.--11. 1. "  [13|0] , "
hexmask.long.byte 0xc 16.--19. 1. "  [14|0] , "
line.quad 0x0f "0xf61f"
hexmask.long.byte 0xc 24.--27. 1. " Weight Table[0|1]         , "
hexmask.long.byte 0x10 0.--3. 1. "  [1|1] , "
hexmask.long.byte 0x10 8.--11. 1. "  [2|1] , "
hexmask.long.byte 0x10 16.--19. 1. "  [3|1] , "
hexmask.long.byte 0x10 24.--27. 1. "  [4|1] , "
hexmask.long.byte 0x14 0.--3. 1. "  [5|1] , "
hexmask.long.byte 0x14 8.--11. 1. "  [6|1] , "
hexmask.long.byte 0x14 16.--19. 1. "  [7|1] , "
hexmask.long.byte 0x14 24.--27. 1. "  [8|1] , "
hexmask.long.byte 0x18 0.--3. 1. "  [9|1] , "
hexmask.long.byte 0x18 8.--11. 1. "  [10|1] , "
hexmask.long.byte 0x18 16.--19. 1. "  [11|1] , "
hexmask.long.byte 0x18 24.--27. 1. "  [12|1] , "
hexmask.long.byte 0x1c 0.--3. 1. "  [13|1] , "
hexmask.long.byte 0x1c 8.--11. 1. "  [14|1] , "
line.quad 0x1e "0xf62e"
hexmask.long.byte 0x1c 16.--19. 1. " Weight Table[0|2]         , "
hexmask.long.byte 0x1c 24.--27. 1. "  [1|2] , "
hexmask.long.byte 0x20 0.--3. 1. "  [2|2] , "
hexmask.long.byte 0x20 8.--11. 1. "  [3|2] , "
hexmask.long.byte 0x20 16.--19. 1. "  [4|2] , "
hexmask.long.byte 0x20 24.--27. 1. "  [5|2] , "
hexmask.long.byte 0x24 0.--3. 1. "  [6|2] , "
hexmask.long.byte 0x24 8.--11. 1. "  [7|2] , "
hexmask.long.byte 0x24 16.--19. 1. "  [8|2] , "
hexmask.long.byte 0x24 24.--27. 1. "  [9|2] , "
hexmask.long.byte 0x28 0.--3. 1. "  [10|2] , "
hexmask.long.byte 0x28 8.--11. 1. "  [11|2] , "
hexmask.long.byte 0x28 16.--19. 1. "  [12|2] , "
hexmask.long.byte 0x28 24.--27. 1. "  [13|2] , "
hexmask.long.byte 0x2c 0.--3. 1. "  [14|2] , "
line.quad 0x2d "0xf63d"
hexmask.long.byte 0x2c 8.--11. 1. " Weight Table[0|3]         , "
hexmask.long.byte 0x2c 16.--19. 1. "  [1|3] , "
hexmask.long.byte 0x2c 24.--27. 1. "  [2|3] , "
hexmask.long.byte 0x30 0.--3. 1. "  [3|3] , "
hexmask.long.byte 0x30 8.--11. 1. "  [4|3] , "
hexmask.long.byte 0x30 16.--19. 1. "  [5|3] , "
hexmask.long.byte 0x30 24.--27. 1. "  [6|3] , "
hexmask.long.byte 0x34 0.--3. 1. "  [7|3] , "
hexmask.long.byte 0x34 8.--11. 1. "  [8|3] , "
hexmask.long.byte 0x34 16.--19. 1. "  [9|3] , "
hexmask.long.byte 0x34 24.--27. 1. "  [10|3] , "
hexmask.long.byte 0x38 0.--3. 1. "  [11|3] , "
hexmask.long.byte 0x38 8.--11. 1. "  [12|3] , "
hexmask.long.byte 0x38 16.--19. 1. "  [13|3] , "
hexmask.long.byte 0x38 24.--27. 1. "  [14|3] , "
line.quad 0x3c "0xf64c"
hexmask.long.byte 0x3c 0.--3. 1. " Weight Table[0|4]         , "
hexmask.long.byte 0x3c 8.--11. 1. "  [1|4] , "
hexmask.long.byte 0x3c 16.--19. 1. "  [2|4] , "
hexmask.long.byte 0x3c 24.--27. 1. "  [3|4] , "
hexmask.long.byte 0x40 0.--3. 1. "  [4|4] , "
hexmask.long.byte 0x40 8.--11. 1. "  [5|4] , "
hexmask.long.byte 0x40 16.--19. 1. "  [6|4] , "
hexmask.long.byte 0x40 24.--27. 1. "  [7|4] , "
hexmask.long.byte 0x44 0.--3. 1. "  [8|4] , "
hexmask.long.byte 0x44 8.--11. 1. "  [9|4] , "
hexmask.long.byte 0x44 16.--19. 1. "  [10|4] , "
hexmask.long.byte 0x44 24.--27. 1. "  [11|4] , "
hexmask.long.byte 0x48 0.--3. 1. "  [12|4] , "
hexmask.long.byte 0x48 8.--11. 1. "  [13|4] , "
hexmask.long.byte 0x48 16.--19. 1. "  [14|4] , "
line.quad 0x4b "0xf65b"
hexmask.long.byte 0x48 24.--27. 1. " Weight Table[0|5]         , "
hexmask.long.byte 0x4c 0.--3. 1. "  [1|5] , "
hexmask.long.byte 0x4c 8.--11. 1. "  [2|5] , "
hexmask.long.byte 0x4c 16.--19. 1. "  [3|5] , "
hexmask.long.byte 0x4c 24.--27. 1. "  [4|5] , "
hexmask.long.byte 0x50 0.--3. 1. "  [5|5] , "
hexmask.long.byte 0x50 8.--11. 1. "  [6|5] , "
hexmask.long.byte 0x50 16.--19. 1. "  [7|5] , "
hexmask.long.byte 0x50 24.--27. 1. "  [8|5] , "
hexmask.long.byte 0x54 0.--3. 1. "  [9|5] , "
hexmask.long.byte 0x54 8.--11. 1. "  [10|5] , "
hexmask.long.byte 0x54 16.--19. 1. "  [11|5] , "
hexmask.long.byte 0x54 24.--27. 1. "  [12|5] , "
hexmask.long.byte 0x58 0.--3. 1. "  [13|5] , "
hexmask.long.byte 0x58 8.--11. 1. "  [14|5] , "
line.quad 0x5a "0xf66a"
hexmask.long.byte 0x58 16.--19. 1. " Weight Table[0|6]         , "
hexmask.long.byte 0x58 24.--27. 1. "  [1|6] , "
hexmask.long.byte 0x5c 0.--3. 1. "  [2|6] , "
hexmask.long.byte 0x5c 8.--11. 1. "  [3|6] , "
hexmask.long.byte 0x5c 16.--19. 1. "  [4|6] , "
hexmask.long.byte 0x5c 24.--27. 1. "  [5|6] , "
hexmask.long.byte 0x60 0.--3. 1. "  [6|6] , "
hexmask.long.byte 0x60 8.--11. 1. "  [7|6] , "
hexmask.long.byte 0x60 16.--19. 1. "  [8|6] , "
hexmask.long.byte 0x60 24.--27. 1. "  [9|6] , "
hexmask.long.byte 0x64 0.--3. 1. "  [10|6] , "
hexmask.long.byte 0x64 8.--11. 1. "  [11|6] , "
hexmask.long.byte 0x64 16.--19. 1. "  [12|6] , "
hexmask.long.byte 0x64 24.--27. 1. "  [13|6] , "
hexmask.long.byte 0x68 0.--3. 1. "  [14|6] , "
line.quad 0x69 "0xf679"
hexmask.long.byte 0x68 8.--11. 1. " Weight Table[0|7]         , "
hexmask.long.byte 0x68 16.--19. 1. "  [1|7] , "
hexmask.long.byte 0x68 24.--27. 1. "  [2|7] , "
hexmask.long.byte 0x6c 0.--3. 1. "  [3|7] , "
hexmask.long.byte 0x6c 8.--11. 1. "  [4|7] , "
hexmask.long.byte 0x6c 16.--19. 1. "  [5|7] , "
hexmask.long.byte 0x6c 24.--27. 1. "  [6|7] , "
hexmask.long.byte 0x70 0.--3. 1. "  [7|7] , "
hexmask.long.byte 0x70 8.--11. 1. "  [8|7] , "
hexmask.long.byte 0x70 16.--19. 1. "  [9|7] , "
hexmask.long.byte 0x70 24.--27. 1. "  [10|7] , "
hexmask.long.byte 0x74 0.--3. 1. "  [11|7] , "
hexmask.long.byte 0x74 8.--11. 1. "  [12|7] , "
hexmask.long.byte 0x74 16.--19. 1. "  [13|7] , "
hexmask.long.byte 0x74 24.--27. 1. "  [14|7] , "
line.quad 0x78 "0xf688"
hexmask.long.byte 0x78 0.--3. 1. " Weight Table[0|8]         , "
hexmask.long.byte 0x78 8.--11. 1. "  [1|8] , "
hexmask.long.byte 0x78 16.--19. 1. "  [2|8] , "
hexmask.long.byte 0x78 24.--27. 1. "  [3|8] , "
hexmask.long.byte 0x7c 0.--3. 1. "  [4|8] , "
hexmask.long.byte 0x7c 8.--11. 1. "  [5|8] , "
hexmask.long.byte 0x7c 16.--19. 1. "  [6|8] , "
hexmask.long.byte 0x7c 24.--27. 1. "  [7|8] , "
hexmask.long.byte 0x80 0.--3. 1. "  [8|8] , "
hexmask.long.byte 0x80 8.--11. 1. "  [9|8] , "
hexmask.long.byte 0x80 16.--19. 1. "  [10|8] , "
hexmask.long.byte 0x80 24.--27. 1. "  [11|8] , "
hexmask.long.byte 0x84 0.--3. 1. "  [12|8] , "
hexmask.long.byte 0x84 8.--11. 1. "  [13|8] , "
hexmask.long.byte 0x84 16.--19. 1. "  [14|8] , "
line.quad 0x87 "0xf697"
hexmask.long.byte 0x84 24.--27. 1. " Weight Table[0|9]         , "
hexmask.long.byte 0x88 0.--3. 1. "  [1|9] , "
hexmask.long.byte 0x88 8.--11. 1. "  [2|9] , "
hexmask.long.byte 0x88 16.--19. 1. "  [3|9] , "
hexmask.long.byte 0x88 24.--27. 1. "  [4|9] , "
hexmask.long.byte 0x8c 0.--3. 1. "  [5|9] , "
hexmask.long.byte 0x8c 8.--11. 1. "  [6|9] , "
hexmask.long.byte 0x8c 16.--19. 1. "  [7|9] , "
hexmask.long.byte 0x8c 24.--27. 1. "  [8|9] , "
hexmask.long.byte 0x90 0.--3. 1. "  [9|9] , "
hexmask.long.byte 0x90 8.--11. 1. "  [10|9] , "
hexmask.long.byte 0x90 16.--19. 1. "  [11|9] , "
hexmask.long.byte 0x90 24.--27. 1. "  [12|9] , "
hexmask.long.byte 0x94 0.--3. 1. "  [13|9] , "
hexmask.long.byte 0x94 8.--11. 1. "  [14|9] , "
line.quad 0x96 "0xf6a6"
hexmask.long.byte 0x94 16.--19. 1. " Weight Table[0|10]        , "
hexmask.long.byte 0x94 24.--27. 1. "  [1|10] , "
hexmask.long.byte 0x98 0.--3. 1. "  [2|10] , "
hexmask.long.byte 0x98 8.--11. 1. "  [3|10] , "
hexmask.long.byte 0x98 16.--19. 1. "  [4|10] , "
hexmask.long.byte 0x98 24.--27. 1. "  [5|10] , "
hexmask.long.byte 0x9c 0.--3. 1. "  [6|10] , "
hexmask.long.byte 0x9c 8.--11. 1. "  [7|10] , "
hexmask.long.byte 0x9c 16.--19. 1. "  [8|10] , "
hexmask.long.byte 0x9c 24.--27. 1. "  [9|10] , "
hexmask.long.byte 0xa0 0.--3. 1. "  [10|10] , "
hexmask.long.byte 0xa0 8.--11. 1. "  [11|10] , "
hexmask.long.byte 0xa0 16.--19. 1. "  [12|10] , "
hexmask.long.byte 0xa0 24.--27. 1. "  [13|10] , "
hexmask.long.byte 0xa4 0.--3. 1. "  [14|10] , "
line.quad 0xa5 "0xf6b5"
hexmask.long.byte 0xa4 8.--11. 1. " Weight Table[0|11]        , "
hexmask.long.byte 0xa4 16.--19. 1. "  [1|11] , "
hexmask.long.byte 0xa4 24.--27. 1. "  [2|11] , "
hexmask.long.byte 0xa8 0.--3. 1. "  [3|11] , "
hexmask.long.byte 0xa8 8.--11. 1. "  [4|11] , "
hexmask.long.byte 0xa8 16.--19. 1. "  [5|11] , "
hexmask.long.byte 0xa8 24.--27. 1. "  [6|11] , "
hexmask.long.byte 0xac 0.--3. 1. "  [7|11] , "
hexmask.long.byte 0xac 8.--11. 1. "  [8|11] , "
hexmask.long.byte 0xac 16.--19. 1. "  [9|11] , "
hexmask.long.byte 0xac 24.--27. 1. "  [10|11] , "
hexmask.long.byte 0xb0 0.--3. 1. "  [11|11] , "
hexmask.long.byte 0xb0 8.--11. 1. "  [12|11] , "
hexmask.long.byte 0xb0 16.--19. 1. "  [13|11] , "
hexmask.long.byte 0xb0 24.--27. 1. "  [14|11] , "
line.quad 0xb4 "0xf6c4"
hexmask.long.byte 0xb4 0.--3. 1. " Weight Table[0|12]        , "
hexmask.long.byte 0xb4 8.--11. 1. "  [1|12] , "
hexmask.long.byte 0xb4 16.--19. 1. "  [2|12] , "
hexmask.long.byte 0xb4 24.--27. 1. "  [3|12] , "
hexmask.long.byte 0xb8 0.--3. 1. "  [4|12] , "
hexmask.long.byte 0xb8 8.--11. 1. "  [5|12] , "
hexmask.long.byte 0xb8 16.--19. 1. "  [6|12] , "
hexmask.long.byte 0xb8 24.--27. 1. "  [7|12] , "
hexmask.long.byte 0xbc 0.--3. 1. "  [8|12] , "
hexmask.long.byte 0xbc 8.--11. 1. "  [9|12] , "
hexmask.long.byte 0xbc 16.--19. 1. "  [10|12] , "
hexmask.long.byte 0xbc 24.--27. 1. "  [11|12] , "
hexmask.long.byte 0xc0 0.--3. 1. "  [12|12] , "
hexmask.long.byte 0xc0 8.--11. 1. "  [13|12] , "
hexmask.long.byte 0xc0 16.--19. 1. "  [14|12] , "
line.quad 0xc3 "0xf6d3"
hexmask.long.byte 0xc0 24.--27. 1. " Weight Table[0|13]        , "
hexmask.long.byte 0xc4 0.--3. 1. "  [1|13] , "
hexmask.long.byte 0xc4 8.--11. 1. "  [2|13] , "
hexmask.long.byte 0xc4 16.--19. 1. "  [3|13] , "
hexmask.long.byte 0xc4 24.--27. 1. "  [4|13] , "
hexmask.long.byte 0xc8 0.--3. 1. "  [5|13] , "
hexmask.long.byte 0xc8 8.--11. 1. "  [6|13] , "
hexmask.long.byte 0xc8 16.--19. 1. "  [7|13] , "
hexmask.long.byte 0xc8 24.--27. 1. "  [8|13] , "
hexmask.long.byte 0xcc 0.--3. 1. "  [9|13] , "
hexmask.long.byte 0xcc 8.--11. 1. "  [10|13] , "
hexmask.long.byte 0xcc 16.--19. 1. "  [11|13] , "
hexmask.long.byte 0xcc 24.--27. 1. "  [12|13] , "
hexmask.long.byte 0xd0 0.--3. 1. "  [13|13] , "
hexmask.long.byte 0xd0 8.--11. 1. "  [14|13] , "
line.quad 0xd2 "0xf6e2"
hexmask.long.byte 0xd0 16.--19. 1. " Weight Table[0|14]        , "
hexmask.long.byte 0xd0 24.--27. 1. "  [1|14] , "
hexmask.long.byte 0xd4 0.--3. 1. "  [2|14] , "
hexmask.long.byte 0xd4 8.--11. 1. "  [3|14] , "
hexmask.long.byte 0xd4 16.--19. 1. "  [4|14] , "
hexmask.long.byte 0xd4 24.--27. 1. "  [5|14] , "
hexmask.long.byte 0xd8 0.--3. 1. "  [6|14] , "
hexmask.long.byte 0xd8 8.--11. 1. "  [7|14] , "
hexmask.long.byte 0xd8 16.--19. 1. "  [8|14] , "
hexmask.long.byte 0xd8 24.--27. 1. "  [9|14] , "
hexmask.long.byte 0xdc 0.--3. 1. "  [10|14] , "
hexmask.long.byte 0xdc 8.--11. 1. "  [11|14] , "
hexmask.long.byte 0xdc 16.--19. 1. "  [12|14] , "
hexmask.long.byte 0xdc 24.--27. 1. "  [13|14] , "
hexmask.long.byte 0xe0 0.--3. 1. "  [14|14] , "
TREE.END
TREE "ROI Histogram 1"
group.long 0xf700++0x3
line.long 0x00 "0xf700"
hexmask.long.byte 0x00 0.--2. 1. " skip x  ,Histogram decimation in horizontal direction: 0=every 2nd pixel; 1=every 3rd pixel; 2=every 4th pixel; 3=every 5th pixel; 4=every 8th pixel ; 5+=every 9th pixel"
hexmask.long.byte 0x00 4.--6. 1. " skip y  ,Histogram decimation in vertical direction: 0=every pixel; 1=every 2nd pixel; 2=every 3rd pixel; 3=every 4th pixel; 4=every 5th pixel; 5=every 8th pixel ; 6+=every 9th pixel"
textline "                 "
bitfld.long 0x00 3. " offset x  , 0= start from the first column;  1=start from second column  "
bitfld.long 0x00 7. " offset y  , 0= start from the first row; 1= start from second row  "
hexmask.long.byte 0x00 8.--10. 1. " Plane mode  ,Plane separation mode (0=Collect all the planes in one histogram, 1=Collect 4 Bayer planes into 4 separate banks, 2=Collect every pixel of 4 Bayer planes into 4 separate banks, 3=Reserved 3, 4=Collect odd  x odd  y plane to bank 0, rest to bank 1, 5=Collect even x odd  y plane to bank 0, rest to bank 1, 6=Collect odd  x even y plane to bank 0, rest to bank 1, 7=Collect even x even y plane to bank 0, rest to bank 1)"
hexmask.long.byte 0x00 16.--17. 1. " RGGB start  ,Starting color of the rggb pattern (0=R Gr   Gb B, 1=Gr R   B Gb, 2=Gb B   R Gr, 3=B Gb   Gr R)"
group.long 0xf704++0x3
line.long 0x00 "0xf704"
hexmask.long.byte 0x00 0.--3. 1. " scale bottom  ,scale of bottom half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
hexmask.long.byte 0x00 4.--7. 1. " scale top  ,scale of top half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
rgroup.long 0xf708++0x3
line.long 0x00 "0xf708"
hexmask.long.long 0x00 0.--31. 1. " Total Pixels  ,Total number of pixels processed (skip x and skip y are taken into account)"
rgroup.long 0xf70c++0x3
line.long 0x00 "0xf70c"
hexmask.long.long 0x00 0.--31. 1. " Counted Pixels  ,Number of pixels accumulated (with nonzero weight)"
group.long 0x0++0x10
group.long 0x0++0x10
group.long 0xf730++0x3
line.long 0x00 "0xf730"
hexmask.long.word 0x00 0.--11. 1. " Gain 00  ,Multiplier for color channel 00 (R)"
group.long 0xf734++0x3
line.long 0x00 "0xf734"
hexmask.long.word 0x00 0.--11. 1. " Gain 01  ,Multiplier for color channel 01 (Gr)"
group.long 0xf738++0x3
line.long 0x00 "0xf738"
hexmask.long.word 0x00 0.--11. 1. " Gain 10  ,Multiplier for color channel 10 (Gb)"
group.long 0xf73c++0x3
line.long 0x00 "0xf73c"
hexmask.long.word 0x00 0.--11. 1. " Gain 11  ,Multiplier for color channel 11 (B)"
group.long 0xf740++0x3
line.long 0x00 "0xf740"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xf744++0x3
line.long 0x00 "0xf744"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xf748++0x3
line.long 0x00 "0xf748"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xf74c++0x3
line.long 0x00 "0xf74c"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
group.long 0xf750++0x3
line.long 0x00 "0xf750"
hexmask.long.word 0x00 0.--15. 1. " start x  ,Horizontal offset from left side of image in pixels for the ROI window"
group.long 0xf754++0x3
line.long 0x00 "0xf754"
hexmask.long.word 0x00 0.--15. 1. " start y  ,Vertical offset from top of image in lines for the ROI window"
group.long 0xf758++0x3
line.long 0x00 "0xf758"
hexmask.long.word 0x00 0.--15. 1. " size x  ,Width of the ROI window"
group.long 0xf75c++0x3
line.long 0x00 "0xf75c"
hexmask.long.word 0x00 0.--15. 1. " size y  ,Height of the ROI window"
TREE.END
TREE "ROI Histogram 2"
group.long 0xf780++0x3
line.long 0x00 "0xf780"
hexmask.long.byte 0x00 0.--2. 1. " skip x  ,Histogram decimation in horizontal direction: 0=every 2nd pixel; 1=every 3rd pixel; 2=every 4th pixel; 3=every 5th pixel; 4=every 8th pixel ; 5+=every 9th pixel"
hexmask.long.byte 0x00 4.--6. 1. " skip y  ,Histogram decimation in vertical direction: 0=every pixel; 1=every 2nd pixel; 2=every 3rd pixel; 3=every 4th pixel; 4=every 5th pixel; 5=every 8th pixel ; 6+=every 9th pixel"
textline "                 "
bitfld.long 0x00 3. " offset x  , 0= start from the first column;  1=start from second column  "
bitfld.long 0x00 7. " offset y  , 0= start from the first row; 1= start from second row  "
hexmask.long.byte 0x00 8.--10. 1. " Plane mode  ,Plane separation mode (0=Collect all the planes in one histogram, 1=Collect 4 Bayer planes into 4 separate banks, 2=Collect every pixel of 4 Bayer planes into 4 separate banks, 3=Reserved 3, 4=Collect odd  x odd  y plane to bank 0, rest to bank 1, 5=Collect even x odd  y plane to bank 0, rest to bank 1, 6=Collect odd  x even y plane to bank 0, rest to bank 1, 7=Collect even x even y plane to bank 0, rest to bank 1)"
hexmask.long.byte 0x00 16.--17. 1. " RGGB start  ,Starting color of the rggb pattern (0=R Gr   Gb B, 1=Gr R   B Gb, 2=Gb B   R Gr, 3=B Gb   Gr R)"
group.long 0xf784++0x3
line.long 0x00 "0xf784"
hexmask.long.byte 0x00 0.--3. 1. " scale bottom  ,scale of bottom half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
hexmask.long.byte 0x00 4.--7. 1. " scale top  ,scale of top half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
rgroup.long 0xf788++0x3
line.long 0x00 "0xf788"
hexmask.long.long 0x00 0.--31. 1. " Total Pixels  ,Total number of pixels processed (skip x and skip y are taken into account)"
rgroup.long 0xf78c++0x3
line.long 0x00 "0xf78c"
hexmask.long.long 0x00 0.--31. 1. " Counted Pixels  ,Number of pixels accumulated (with nonzero weight)"
group.long 0x0++0x10
group.long 0x0++0x10
group.long 0xf7b0++0x3
line.long 0x00 "0xf7b0"
hexmask.long.word 0x00 0.--11. 1. " Gain 00  ,Multiplier for color channel 00 (R)"
group.long 0xf7b4++0x3
line.long 0x00 "0xf7b4"
hexmask.long.word 0x00 0.--11. 1. " Gain 01  ,Multiplier for color channel 01 (Gr)"
group.long 0xf7b8++0x3
line.long 0x00 "0xf7b8"
hexmask.long.word 0x00 0.--11. 1. " Gain 10  ,Multiplier for color channel 10 (Gb)"
group.long 0xf7bc++0x3
line.long 0x00 "0xf7bc"
hexmask.long.word 0x00 0.--11. 1. " Gain 11  ,Multiplier for color channel 11 (B)"
group.long 0xf7c0++0x3
line.long 0x00 "0xf7c0"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xf7c4++0x3
line.long 0x00 "0xf7c4"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xf7c8++0x3
line.long 0x00 "0xf7c8"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xf7cc++0x3
line.long 0x00 "0xf7cc"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
group.long 0xf7d0++0x3
line.long 0x00 "0xf7d0"
hexmask.long.word 0x00 0.--15. 1. " start x  ,Horizontal offset from left side of image in pixels for the ROI window"
group.long 0xf7d4++0x3
line.long 0x00 "0xf7d4"
hexmask.long.word 0x00 0.--15. 1. " start y  ,Vertical offset from top of image in lines for the ROI window"
group.long 0xf7d8++0x3
line.long 0x00 "0xf7d8"
hexmask.long.word 0x00 0.--15. 1. " size x  ,Width of the ROI window"
group.long 0xf7dc++0x3
line.long 0x00 "0xf7dc"
hexmask.long.word 0x00 0.--15. 1. " size y  ,Height of the ROI window"
TREE.END
TREE "ROI Histogram 3"
group.long 0xf800++0x3
line.long 0x00 "0xf800"
hexmask.long.byte 0x00 0.--2. 1. " skip x  ,Histogram decimation in horizontal direction: 0=every 2nd pixel; 1=every 3rd pixel; 2=every 4th pixel; 3=every 5th pixel; 4=every 8th pixel ; 5+=every 9th pixel"
hexmask.long.byte 0x00 4.--6. 1. " skip y  ,Histogram decimation in vertical direction: 0=every pixel; 1=every 2nd pixel; 2=every 3rd pixel; 3=every 4th pixel; 4=every 5th pixel; 5=every 8th pixel ; 6+=every 9th pixel"
textline "                 "
bitfld.long 0x00 3. " offset x  , 0= start from the first column;  1=start from second column  "
bitfld.long 0x00 7. " offset y  , 0= start from the first row; 1= start from second row  "
hexmask.long.byte 0x00 8.--10. 1. " Plane mode  ,Plane separation mode (0=Collect all the planes in one histogram, 1=Collect 4 Bayer planes into 4 separate banks, 2=Collect every pixel of 4 Bayer planes into 4 separate banks, 3=Reserved 3, 4=Collect odd  x odd  y plane to bank 0, rest to bank 1, 5=Collect even x odd  y plane to bank 0, rest to bank 1, 6=Collect odd  x even y plane to bank 0, rest to bank 1, 7=Collect even x even y plane to bank 0, rest to bank 1)"
hexmask.long.byte 0x00 16.--17. 1. " RGGB start  ,Starting color of the rggb pattern (0=R Gr   Gb B, 1=Gr R   B Gb, 2=Gb B   R Gr, 3=B Gb   Gr R)"
group.long 0xf804++0x3
line.long 0x00 "0xf804"
hexmask.long.byte 0x00 0.--3. 1. " scale bottom  ,scale of bottom half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
hexmask.long.byte 0x00 4.--7. 1. " scale top  ,scale of top half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
rgroup.long 0xf808++0x3
line.long 0x00 "0xf808"
hexmask.long.long 0x00 0.--31. 1. " Total Pixels  ,Total number of pixels processed (skip x and skip y are taken into account)"
rgroup.long 0xf80c++0x3
line.long 0x00 "0xf80c"
hexmask.long.long 0x00 0.--31. 1. " Counted Pixels  ,Number of pixels accumulated (with nonzero weight)"
group.long 0x0++0x10
group.long 0x0++0x10
group.long 0xf830++0x3
line.long 0x00 "0xf830"
hexmask.long.word 0x00 0.--11. 1. " Gain 00  ,Multiplier for color channel 00 (R)"
group.long 0xf834++0x3
line.long 0x00 "0xf834"
hexmask.long.word 0x00 0.--11. 1. " Gain 01  ,Multiplier for color channel 01 (Gr)"
group.long 0xf838++0x3
line.long 0x00 "0xf838"
hexmask.long.word 0x00 0.--11. 1. " Gain 10  ,Multiplier for color channel 10 (Gb)"
group.long 0xf83c++0x3
line.long 0x00 "0xf83c"
hexmask.long.word 0x00 0.--11. 1. " Gain 11  ,Multiplier for color channel 11 (B)"
group.long 0xf840++0x3
line.long 0x00 "0xf840"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xf844++0x3
line.long 0x00 "0xf844"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xf848++0x3
line.long 0x00 "0xf848"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xf84c++0x3
line.long 0x00 "0xf84c"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
group.long 0xf850++0x3
line.long 0x00 "0xf850"
hexmask.long.word 0x00 0.--15. 1. " start x  ,Horizontal offset from left side of image in pixels for the ROI window"
group.long 0xf854++0x3
line.long 0x00 "0xf854"
hexmask.long.word 0x00 0.--15. 1. " start y  ,Vertical offset from top of image in lines for the ROI window"
group.long 0xf858++0x3
line.long 0x00 "0xf858"
hexmask.long.word 0x00 0.--15. 1. " size x  ,Width of the ROI window"
group.long 0xf85c++0x3
line.long 0x00 "0xf85c"
hexmask.long.word 0x00 0.--15. 1. " size y  ,Height of the ROI window"
TREE.END
TREE "ROI Histogram 4"
group.long 0xf880++0x3
line.long 0x00 "0xf880"
hexmask.long.byte 0x00 0.--2. 1. " skip x  ,Histogram decimation in horizontal direction: 0=every 2nd pixel; 1=every 3rd pixel; 2=every 4th pixel; 3=every 5th pixel; 4=every 8th pixel ; 5+=every 9th pixel"
hexmask.long.byte 0x00 4.--6. 1. " skip y  ,Histogram decimation in vertical direction: 0=every pixel; 1=every 2nd pixel; 2=every 3rd pixel; 3=every 4th pixel; 4=every 5th pixel; 5=every 8th pixel ; 6+=every 9th pixel"
textline "                 "
bitfld.long 0x00 3. " offset x  , 0= start from the first column;  1=start from second column  "
bitfld.long 0x00 7. " offset y  , 0= start from the first row; 1= start from second row  "
hexmask.long.byte 0x00 8.--10. 1. " Plane mode  ,Plane separation mode (0=Collect all the planes in one histogram, 1=Collect 4 Bayer planes into 4 separate banks, 2=Collect every pixel of 4 Bayer planes into 4 separate banks, 3=Reserved 3, 4=Collect odd  x odd  y plane to bank 0, rest to bank 1, 5=Collect even x odd  y plane to bank 0, rest to bank 1, 6=Collect odd  x even y plane to bank 0, rest to bank 1, 7=Collect even x even y plane to bank 0, rest to bank 1)"
hexmask.long.byte 0x00 16.--17. 1. " RGGB start  ,Starting color of the rggb pattern (0=R Gr   Gb B, 1=Gr R   B Gb, 2=Gb B   R Gr, 3=B Gb   Gr R)"
group.long 0xf884++0x3
line.long 0x00 "0xf884"
hexmask.long.byte 0x00 0.--3. 1. " scale bottom  ,scale of bottom half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
hexmask.long.byte 0x00 4.--7. 1. " scale top  ,scale of top half of the range: 0=1x ,1=2x, 2=4x, 4=8x, 4=16x"
rgroup.long 0xf888++0x3
line.long 0x00 "0xf888"
hexmask.long.long 0x00 0.--31. 1. " Total Pixels  ,Total number of pixels processed (skip x and skip y are taken into account)"
rgroup.long 0xf88c++0x3
line.long 0x00 "0xf88c"
hexmask.long.long 0x00 0.--31. 1. " Counted Pixels  ,Number of pixels accumulated (with nonzero weight)"
group.long 0x0++0x10
group.long 0x0++0x10
group.long 0xf8b0++0x3
line.long 0x00 "0xf8b0"
hexmask.long.word 0x00 0.--11. 1. " Gain 00  ,Multiplier for color channel 00 (R)"
group.long 0xf8b4++0x3
line.long 0x00 "0xf8b4"
hexmask.long.word 0x00 0.--11. 1. " Gain 01  ,Multiplier for color channel 01 (Gr)"
group.long 0xf8b8++0x3
line.long 0x00 "0xf8b8"
hexmask.long.word 0x00 0.--11. 1. " Gain 10  ,Multiplier for color channel 10 (Gb)"
group.long 0xf8bc++0x3
line.long 0x00 "0xf8bc"
hexmask.long.word 0x00 0.--11. 1. " Gain 11  ,Multiplier for color channel 11 (B)"
group.long 0xf8c0++0x3
line.long 0x00 "0xf8c0"
hexmask.long.long 0x00 0.--19. 1. " Black 00  ,Black offset for color channel 00 (R)"
group.long 0xf8c4++0x3
line.long 0x00 "0xf8c4"
hexmask.long.long 0x00 0.--19. 1. " Black 01  ,Black offset for color channel 01 (Gr)"
group.long 0xf8c8++0x3
line.long 0x00 "0xf8c8"
hexmask.long.long 0x00 0.--19. 1. " Black 10  ,Black offset for color channel 10 (Gb)"
group.long 0xf8cc++0x3
line.long 0x00 "0xf8cc"
hexmask.long.long 0x00 0.--19. 1. " Black 11  ,Black offset for color channel 11 (B)"
group.long 0xf8d0++0x3
line.long 0x00 "0xf8d0"
hexmask.long.word 0x00 0.--15. 1. " start x  ,Horizontal offset from left side of image in pixels for the ROI window"
group.long 0xf8d4++0x3
line.long 0x00 "0xf8d4"
hexmask.long.word 0x00 0.--15. 1. " start y  ,Vertical offset from top of image in lines for the ROI window"
group.long 0xf8d8++0x3
line.long 0x00 "0xf8d8"
hexmask.long.word 0x00 0.--15. 1. " size x  ,Width of the ROI window"
group.long 0xf8dc++0x3
line.long 0x00 "0xf8dc"
hexmask.long.word 0x00 0.--15. 1. " size y  ,Height of the ROI window"
TREE.END
TREE "Iridix LUT"
group.long 0x0++0x104
group.long 0x0++0x84
group.long 0x0++0x84
TREE.END
TREE "Noise Profile RAW frontend LUT"
group.long 0xfa80++0x80
line.quad 0x00 "0xfa80"
hexmask.long.byte 0x0 0.--7. 1. " Weight lut[0]             , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.long.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.long.byte 0x4 8.--15. 1. "  [5]  , "
hexmask.long.byte 0x4 16.--23. 1. "  [6]  , "
hexmask.long.byte 0x4 24.--31. 1. "  [7]  , "
hexmask.long.byte 0x8 0.--7. 1. "  [8]  , "
hexmask.long.byte 0x8 8.--15. 1. "  [9]  , "
hexmask.long.byte 0x8 16.--23. 1. "  [10] , "
hexmask.long.byte 0x8 24.--31. 1. "  [11] , "
hexmask.long.byte 0xc 0.--7. 1. "  [12] , "
hexmask.long.byte 0xc 8.--15. 1. "  [13] , "
hexmask.long.byte 0xc 16.--23. 1. "  [14] , "
hexmask.long.byte 0xc 24.--31. 1. "  [15] , "
hexmask.long.byte 0x10 0.--7. 1. "  [16] , "
hexmask.long.byte 0x10 8.--15. 1. "  [17] , "
hexmask.long.byte 0x10 16.--23. 1. "  [18] , "
hexmask.long.byte 0x10 24.--31. 1. "  [19] , "
hexmask.long.byte 0x14 0.--7. 1. "  [20] , "
hexmask.long.byte 0x14 8.--15. 1. "  [21] , "
hexmask.long.byte 0x14 16.--23. 1. "  [22] , "
hexmask.long.byte 0x14 24.--31. 1. "  [23] , "
hexmask.long.byte 0x18 0.--7. 1. "  [24] , "
hexmask.long.byte 0x18 8.--15. 1. "  [25] , "
hexmask.long.byte 0x18 16.--23. 1. "  [26] , "
hexmask.long.byte 0x18 24.--31. 1. "  [27] , "
hexmask.long.byte 0x1c 0.--7. 1. "  [28] , "
hexmask.long.byte 0x1c 8.--15. 1. "  [29] , "
hexmask.long.byte 0x1c 16.--23. 1. "  [30] , "
hexmask.long.byte 0x1c 24.--31. 1. "  [31] , "
hexmask.long.byte 0x20 0.--7. 1. "  [32] , "
hexmask.long.byte 0x20 8.--15. 1. "  [33] , "
hexmask.long.byte 0x20 16.--23. 1. "  [34] , "
hexmask.long.byte 0x20 24.--31. 1. "  [35] , "
hexmask.long.byte 0x24 0.--7. 1. "  [36] , "
hexmask.long.byte 0x24 8.--15. 1. "  [37] , "
hexmask.long.byte 0x24 16.--23. 1. "  [38] , "
hexmask.long.byte 0x24 24.--31. 1. "  [39] , "
hexmask.long.byte 0x28 0.--7. 1. "  [40] , "
hexmask.long.byte 0x28 8.--15. 1. "  [41] , "
hexmask.long.byte 0x28 16.--23. 1. "  [42] , "
hexmask.long.byte 0x28 24.--31. 1. "  [43] , "
hexmask.long.byte 0x2c 0.--7. 1. "  [44] , "
hexmask.long.byte 0x2c 8.--15. 1. "  [45] , "
hexmask.long.byte 0x2c 16.--23. 1. "  [46] , "
hexmask.long.byte 0x2c 24.--31. 1. "  [47] , "
hexmask.long.byte 0x30 0.--7. 1. "  [48] , "
hexmask.long.byte 0x30 8.--15. 1. "  [49] , "
hexmask.long.byte 0x30 16.--23. 1. "  [50] , "
hexmask.long.byte 0x30 24.--31. 1. "  [51] , "
hexmask.long.byte 0x34 0.--7. 1. "  [52] , "
hexmask.long.byte 0x34 8.--15. 1. "  [53] , "
hexmask.long.byte 0x34 16.--23. 1. "  [54] , "
hexmask.long.byte 0x34 24.--31. 1. "  [55] , "
hexmask.long.byte 0x38 0.--7. 1. "  [56] , "
hexmask.long.byte 0x38 8.--15. 1. "  [57] , "
hexmask.long.byte 0x38 16.--23. 1. "  [58] , "
hexmask.long.byte 0x38 24.--31. 1. "  [59] , "
hexmask.long.byte 0x3c 0.--7. 1. "  [60] , "
hexmask.long.byte 0x3c 8.--15. 1. "  [61] , "
hexmask.long.byte 0x3c 16.--23. 1. "  [62] , "
hexmask.long.byte 0x3c 24.--31. 1. "  [63] , "
hexmask.long.byte 0x40 0.--7. 1. "  [64] , "
hexmask.long.byte 0x40 8.--15. 1. "  [65] , "
hexmask.long.byte 0x40 16.--23. 1. "  [66] , "
hexmask.long.byte 0x40 24.--31. 1. "  [67] , "
hexmask.long.byte 0x44 0.--7. 1. "  [68] , "
hexmask.long.byte 0x44 8.--15. 1. "  [69] , "
hexmask.long.byte 0x44 16.--23. 1. "  [70] , "
hexmask.long.byte 0x44 24.--31. 1. "  [71] , "
hexmask.long.byte 0x48 0.--7. 1. "  [72] , "
hexmask.long.byte 0x48 8.--15. 1. "  [73] , "
hexmask.long.byte 0x48 16.--23. 1. "  [74] , "
hexmask.long.byte 0x48 24.--31. 1. "  [75] , "
hexmask.long.byte 0x4c 0.--7. 1. "  [76] , "
hexmask.long.byte 0x4c 8.--15. 1. "  [77] , "
hexmask.long.byte 0x4c 16.--23. 1. "  [78] , "
hexmask.long.byte 0x4c 24.--31. 1. "  [79] , "
hexmask.long.byte 0x50 0.--7. 1. "  [80] , "
hexmask.long.byte 0x50 8.--15. 1. "  [81] , "
hexmask.long.byte 0x50 16.--23. 1. "  [82] , "
hexmask.long.byte 0x50 24.--31. 1. "  [83] , "
hexmask.long.byte 0x54 0.--7. 1. "  [84] , "
hexmask.long.byte 0x54 8.--15. 1. "  [85] , "
hexmask.long.byte 0x54 16.--23. 1. "  [86] , "
hexmask.long.byte 0x54 24.--31. 1. "  [87] , "
hexmask.long.byte 0x58 0.--7. 1. "  [88] , "
hexmask.long.byte 0x58 8.--15. 1. "  [89] , "
hexmask.long.byte 0x58 16.--23. 1. "  [90] , "
hexmask.long.byte 0x58 24.--31. 1. "  [91] , "
hexmask.long.byte 0x5c 0.--7. 1. "  [92] , "
hexmask.long.byte 0x5c 8.--15. 1. "  [93] , "
hexmask.long.byte 0x5c 16.--23. 1. "  [94] , "
hexmask.long.byte 0x5c 24.--31. 1. "  [95] , "
hexmask.long.byte 0x60 0.--7. 1. "  [96] , "
hexmask.long.byte 0x60 8.--15. 1. "  [97] , "
hexmask.long.byte 0x60 16.--23. 1. "  [98] , "
hexmask.long.byte 0x60 24.--31. 1. "  [99] , "
hexmask.long.byte 0x64 0.--7. 1. "  [100] , "
hexmask.long.byte 0x64 8.--15. 1. "  [101] , "
hexmask.long.byte 0x64 16.--23. 1. "  [102] , "
hexmask.long.byte 0x64 24.--31. 1. "  [103] , "
hexmask.long.byte 0x68 0.--7. 1. "  [104] , "
hexmask.long.byte 0x68 8.--15. 1. "  [105] , "
hexmask.long.byte 0x68 16.--23. 1. "  [106] , "
hexmask.long.byte 0x68 24.--31. 1. "  [107] , "
hexmask.long.byte 0x6c 0.--7. 1. "  [108] , "
hexmask.long.byte 0x6c 8.--15. 1. "  [109] , "
hexmask.long.byte 0x6c 16.--23. 1. "  [110] , "
hexmask.long.byte 0x6c 24.--31. 1. "  [111] , "
hexmask.long.byte 0x70 0.--7. 1. "  [112] , "
hexmask.long.byte 0x70 8.--15. 1. "  [113] , "
hexmask.long.byte 0x70 16.--23. 1. "  [114] , "
hexmask.long.byte 0x70 24.--31. 1. "  [115] , "
hexmask.long.byte 0x74 0.--7. 1. "  [116] , "
hexmask.long.byte 0x74 8.--15. 1. "  [117] , "
hexmask.long.byte 0x74 16.--23. 1. "  [118] , "
hexmask.long.byte 0x74 24.--31. 1. "  [119] , "
hexmask.long.byte 0x78 0.--7. 1. "  [120] , "
hexmask.long.byte 0x78 8.--15. 1. "  [121] , "
hexmask.long.byte 0x78 16.--23. 1. "  [122] , "
hexmask.long.byte 0x78 24.--31. 1. "  [123] , "
hexmask.long.byte 0x7c 0.--7. 1. "  [124] , "
hexmask.long.byte 0x7c 8.--15. 1. "  [125] , "
hexmask.long.byte 0x7c 16.--23. 1. "  [126] , "
hexmask.long.byte 0x7c 24.--31. 1. "  [127] , "
TREE.END
TREE "Noise Profile Frame Stitch LUT VS"
group.long 0xfb00++0x80
line.quad 0x00 "0xfb00"
hexmask.long.byte 0x0 0.--7. 1. " Weight lut[0]             , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.long.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.long.byte 0x4 8.--15. 1. "  [5]  , "
hexmask.long.byte 0x4 16.--23. 1. "  [6]  , "
hexmask.long.byte 0x4 24.--31. 1. "  [7]  , "
hexmask.long.byte 0x8 0.--7. 1. "  [8]  , "
hexmask.long.byte 0x8 8.--15. 1. "  [9]  , "
hexmask.long.byte 0x8 16.--23. 1. "  [10] , "
hexmask.long.byte 0x8 24.--31. 1. "  [11] , "
hexmask.long.byte 0xc 0.--7. 1. "  [12] , "
hexmask.long.byte 0xc 8.--15. 1. "  [13] , "
hexmask.long.byte 0xc 16.--23. 1. "  [14] , "
hexmask.long.byte 0xc 24.--31. 1. "  [15] , "
hexmask.long.byte 0x10 0.--7. 1. "  [16] , "
hexmask.long.byte 0x10 8.--15. 1. "  [17] , "
hexmask.long.byte 0x10 16.--23. 1. "  [18] , "
hexmask.long.byte 0x10 24.--31. 1. "  [19] , "
hexmask.long.byte 0x14 0.--7. 1. "  [20] , "
hexmask.long.byte 0x14 8.--15. 1. "  [21] , "
hexmask.long.byte 0x14 16.--23. 1. "  [22] , "
hexmask.long.byte 0x14 24.--31. 1. "  [23] , "
hexmask.long.byte 0x18 0.--7. 1. "  [24] , "
hexmask.long.byte 0x18 8.--15. 1. "  [25] , "
hexmask.long.byte 0x18 16.--23. 1. "  [26] , "
hexmask.long.byte 0x18 24.--31. 1. "  [27] , "
hexmask.long.byte 0x1c 0.--7. 1. "  [28] , "
hexmask.long.byte 0x1c 8.--15. 1. "  [29] , "
hexmask.long.byte 0x1c 16.--23. 1. "  [30] , "
hexmask.long.byte 0x1c 24.--31. 1. "  [31] , "
hexmask.long.byte 0x20 0.--7. 1. "  [32] , "
hexmask.long.byte 0x20 8.--15. 1. "  [33] , "
hexmask.long.byte 0x20 16.--23. 1. "  [34] , "
hexmask.long.byte 0x20 24.--31. 1. "  [35] , "
hexmask.long.byte 0x24 0.--7. 1. "  [36] , "
hexmask.long.byte 0x24 8.--15. 1. "  [37] , "
hexmask.long.byte 0x24 16.--23. 1. "  [38] , "
hexmask.long.byte 0x24 24.--31. 1. "  [39] , "
hexmask.long.byte 0x28 0.--7. 1. "  [40] , "
hexmask.long.byte 0x28 8.--15. 1. "  [41] , "
hexmask.long.byte 0x28 16.--23. 1. "  [42] , "
hexmask.long.byte 0x28 24.--31. 1. "  [43] , "
hexmask.long.byte 0x2c 0.--7. 1. "  [44] , "
hexmask.long.byte 0x2c 8.--15. 1. "  [45] , "
hexmask.long.byte 0x2c 16.--23. 1. "  [46] , "
hexmask.long.byte 0x2c 24.--31. 1. "  [47] , "
hexmask.long.byte 0x30 0.--7. 1. "  [48] , "
hexmask.long.byte 0x30 8.--15. 1. "  [49] , "
hexmask.long.byte 0x30 16.--23. 1. "  [50] , "
hexmask.long.byte 0x30 24.--31. 1. "  [51] , "
hexmask.long.byte 0x34 0.--7. 1. "  [52] , "
hexmask.long.byte 0x34 8.--15. 1. "  [53] , "
hexmask.long.byte 0x34 16.--23. 1. "  [54] , "
hexmask.long.byte 0x34 24.--31. 1. "  [55] , "
hexmask.long.byte 0x38 0.--7. 1. "  [56] , "
hexmask.long.byte 0x38 8.--15. 1. "  [57] , "
hexmask.long.byte 0x38 16.--23. 1. "  [58] , "
hexmask.long.byte 0x38 24.--31. 1. "  [59] , "
hexmask.long.byte 0x3c 0.--7. 1. "  [60] , "
hexmask.long.byte 0x3c 8.--15. 1. "  [61] , "
hexmask.long.byte 0x3c 16.--23. 1. "  [62] , "
hexmask.long.byte 0x3c 24.--31. 1. "  [63] , "
hexmask.long.byte 0x40 0.--7. 1. "  [64] , "
hexmask.long.byte 0x40 8.--15. 1. "  [65] , "
hexmask.long.byte 0x40 16.--23. 1. "  [66] , "
hexmask.long.byte 0x40 24.--31. 1. "  [67] , "
hexmask.long.byte 0x44 0.--7. 1. "  [68] , "
hexmask.long.byte 0x44 8.--15. 1. "  [69] , "
hexmask.long.byte 0x44 16.--23. 1. "  [70] , "
hexmask.long.byte 0x44 24.--31. 1. "  [71] , "
hexmask.long.byte 0x48 0.--7. 1. "  [72] , "
hexmask.long.byte 0x48 8.--15. 1. "  [73] , "
hexmask.long.byte 0x48 16.--23. 1. "  [74] , "
hexmask.long.byte 0x48 24.--31. 1. "  [75] , "
hexmask.long.byte 0x4c 0.--7. 1. "  [76] , "
hexmask.long.byte 0x4c 8.--15. 1. "  [77] , "
hexmask.long.byte 0x4c 16.--23. 1. "  [78] , "
hexmask.long.byte 0x4c 24.--31. 1. "  [79] , "
hexmask.long.byte 0x50 0.--7. 1. "  [80] , "
hexmask.long.byte 0x50 8.--15. 1. "  [81] , "
hexmask.long.byte 0x50 16.--23. 1. "  [82] , "
hexmask.long.byte 0x50 24.--31. 1. "  [83] , "
hexmask.long.byte 0x54 0.--7. 1. "  [84] , "
hexmask.long.byte 0x54 8.--15. 1. "  [85] , "
hexmask.long.byte 0x54 16.--23. 1. "  [86] , "
hexmask.long.byte 0x54 24.--31. 1. "  [87] , "
hexmask.long.byte 0x58 0.--7. 1. "  [88] , "
hexmask.long.byte 0x58 8.--15. 1. "  [89] , "
hexmask.long.byte 0x58 16.--23. 1. "  [90] , "
hexmask.long.byte 0x58 24.--31. 1. "  [91] , "
hexmask.long.byte 0x5c 0.--7. 1. "  [92] , "
hexmask.long.byte 0x5c 8.--15. 1. "  [93] , "
hexmask.long.byte 0x5c 16.--23. 1. "  [94] , "
hexmask.long.byte 0x5c 24.--31. 1. "  [95] , "
hexmask.long.byte 0x60 0.--7. 1. "  [96] , "
hexmask.long.byte 0x60 8.--15. 1. "  [97] , "
hexmask.long.byte 0x60 16.--23. 1. "  [98] , "
hexmask.long.byte 0x60 24.--31. 1. "  [99] , "
hexmask.long.byte 0x64 0.--7. 1. "  [100] , "
hexmask.long.byte 0x64 8.--15. 1. "  [101] , "
hexmask.long.byte 0x64 16.--23. 1. "  [102] , "
hexmask.long.byte 0x64 24.--31. 1. "  [103] , "
hexmask.long.byte 0x68 0.--7. 1. "  [104] , "
hexmask.long.byte 0x68 8.--15. 1. "  [105] , "
hexmask.long.byte 0x68 16.--23. 1. "  [106] , "
hexmask.long.byte 0x68 24.--31. 1. "  [107] , "
hexmask.long.byte 0x6c 0.--7. 1. "  [108] , "
hexmask.long.byte 0x6c 8.--15. 1. "  [109] , "
hexmask.long.byte 0x6c 16.--23. 1. "  [110] , "
hexmask.long.byte 0x6c 24.--31. 1. "  [111] , "
hexmask.long.byte 0x70 0.--7. 1. "  [112] , "
hexmask.long.byte 0x70 8.--15. 1. "  [113] , "
hexmask.long.byte 0x70 16.--23. 1. "  [114] , "
hexmask.long.byte 0x70 24.--31. 1. "  [115] , "
hexmask.long.byte 0x74 0.--7. 1. "  [116] , "
hexmask.long.byte 0x74 8.--15. 1. "  [117] , "
hexmask.long.byte 0x74 16.--23. 1. "  [118] , "
hexmask.long.byte 0x74 24.--31. 1. "  [119] , "
hexmask.long.byte 0x78 0.--7. 1. "  [120] , "
hexmask.long.byte 0x78 8.--15. 1. "  [121] , "
hexmask.long.byte 0x78 16.--23. 1. "  [122] , "
hexmask.long.byte 0x78 24.--31. 1. "  [123] , "
hexmask.long.byte 0x7c 0.--7. 1. "  [124] , "
hexmask.long.byte 0x7c 8.--15. 1. "  [125] , "
hexmask.long.byte 0x7c 16.--23. 1. "  [126] , "
hexmask.long.byte 0x7c 24.--31. 1. "  [127] , "
TREE.END
TREE "Noise Profile Frame Stitch LUT S"
group.long 0xfb80++0x80
line.quad 0x00 "0xfb80"
hexmask.long.byte 0x0 0.--7. 1. " Weight lut[0]             , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.long.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.long.byte 0x4 8.--15. 1. "  [5]  , "
hexmask.long.byte 0x4 16.--23. 1. "  [6]  , "
hexmask.long.byte 0x4 24.--31. 1. "  [7]  , "
hexmask.long.byte 0x8 0.--7. 1. "  [8]  , "
hexmask.long.byte 0x8 8.--15. 1. "  [9]  , "
hexmask.long.byte 0x8 16.--23. 1. "  [10] , "
hexmask.long.byte 0x8 24.--31. 1. "  [11] , "
hexmask.long.byte 0xc 0.--7. 1. "  [12] , "
hexmask.long.byte 0xc 8.--15. 1. "  [13] , "
hexmask.long.byte 0xc 16.--23. 1. "  [14] , "
hexmask.long.byte 0xc 24.--31. 1. "  [15] , "
hexmask.long.byte 0x10 0.--7. 1. "  [16] , "
hexmask.long.byte 0x10 8.--15. 1. "  [17] , "
hexmask.long.byte 0x10 16.--23. 1. "  [18] , "
hexmask.long.byte 0x10 24.--31. 1. "  [19] , "
hexmask.long.byte 0x14 0.--7. 1. "  [20] , "
hexmask.long.byte 0x14 8.--15. 1. "  [21] , "
hexmask.long.byte 0x14 16.--23. 1. "  [22] , "
hexmask.long.byte 0x14 24.--31. 1. "  [23] , "
hexmask.long.byte 0x18 0.--7. 1. "  [24] , "
hexmask.long.byte 0x18 8.--15. 1. "  [25] , "
hexmask.long.byte 0x18 16.--23. 1. "  [26] , "
hexmask.long.byte 0x18 24.--31. 1. "  [27] , "
hexmask.long.byte 0x1c 0.--7. 1. "  [28] , "
hexmask.long.byte 0x1c 8.--15. 1. "  [29] , "
hexmask.long.byte 0x1c 16.--23. 1. "  [30] , "
hexmask.long.byte 0x1c 24.--31. 1. "  [31] , "
hexmask.long.byte 0x20 0.--7. 1. "  [32] , "
hexmask.long.byte 0x20 8.--15. 1. "  [33] , "
hexmask.long.byte 0x20 16.--23. 1. "  [34] , "
hexmask.long.byte 0x20 24.--31. 1. "  [35] , "
hexmask.long.byte 0x24 0.--7. 1. "  [36] , "
hexmask.long.byte 0x24 8.--15. 1. "  [37] , "
hexmask.long.byte 0x24 16.--23. 1. "  [38] , "
hexmask.long.byte 0x24 24.--31. 1. "  [39] , "
hexmask.long.byte 0x28 0.--7. 1. "  [40] , "
hexmask.long.byte 0x28 8.--15. 1. "  [41] , "
hexmask.long.byte 0x28 16.--23. 1. "  [42] , "
hexmask.long.byte 0x28 24.--31. 1. "  [43] , "
hexmask.long.byte 0x2c 0.--7. 1. "  [44] , "
hexmask.long.byte 0x2c 8.--15. 1. "  [45] , "
hexmask.long.byte 0x2c 16.--23. 1. "  [46] , "
hexmask.long.byte 0x2c 24.--31. 1. "  [47] , "
hexmask.long.byte 0x30 0.--7. 1. "  [48] , "
hexmask.long.byte 0x30 8.--15. 1. "  [49] , "
hexmask.long.byte 0x30 16.--23. 1. "  [50] , "
hexmask.long.byte 0x30 24.--31. 1. "  [51] , "
hexmask.long.byte 0x34 0.--7. 1. "  [52] , "
hexmask.long.byte 0x34 8.--15. 1. "  [53] , "
hexmask.long.byte 0x34 16.--23. 1. "  [54] , "
hexmask.long.byte 0x34 24.--31. 1. "  [55] , "
hexmask.long.byte 0x38 0.--7. 1. "  [56] , "
hexmask.long.byte 0x38 8.--15. 1. "  [57] , "
hexmask.long.byte 0x38 16.--23. 1. "  [58] , "
hexmask.long.byte 0x38 24.--31. 1. "  [59] , "
hexmask.long.byte 0x3c 0.--7. 1. "  [60] , "
hexmask.long.byte 0x3c 8.--15. 1. "  [61] , "
hexmask.long.byte 0x3c 16.--23. 1. "  [62] , "
hexmask.long.byte 0x3c 24.--31. 1. "  [63] , "
hexmask.long.byte 0x40 0.--7. 1. "  [64] , "
hexmask.long.byte 0x40 8.--15. 1. "  [65] , "
hexmask.long.byte 0x40 16.--23. 1. "  [66] , "
hexmask.long.byte 0x40 24.--31. 1. "  [67] , "
hexmask.long.byte 0x44 0.--7. 1. "  [68] , "
hexmask.long.byte 0x44 8.--15. 1. "  [69] , "
hexmask.long.byte 0x44 16.--23. 1. "  [70] , "
hexmask.long.byte 0x44 24.--31. 1. "  [71] , "
hexmask.long.byte 0x48 0.--7. 1. "  [72] , "
hexmask.long.byte 0x48 8.--15. 1. "  [73] , "
hexmask.long.byte 0x48 16.--23. 1. "  [74] , "
hexmask.long.byte 0x48 24.--31. 1. "  [75] , "
hexmask.long.byte 0x4c 0.--7. 1. "  [76] , "
hexmask.long.byte 0x4c 8.--15. 1. "  [77] , "
hexmask.long.byte 0x4c 16.--23. 1. "  [78] , "
hexmask.long.byte 0x4c 24.--31. 1. "  [79] , "
hexmask.long.byte 0x50 0.--7. 1. "  [80] , "
hexmask.long.byte 0x50 8.--15. 1. "  [81] , "
hexmask.long.byte 0x50 16.--23. 1. "  [82] , "
hexmask.long.byte 0x50 24.--31. 1. "  [83] , "
hexmask.long.byte 0x54 0.--7. 1. "  [84] , "
hexmask.long.byte 0x54 8.--15. 1. "  [85] , "
hexmask.long.byte 0x54 16.--23. 1. "  [86] , "
hexmask.long.byte 0x54 24.--31. 1. "  [87] , "
hexmask.long.byte 0x58 0.--7. 1. "  [88] , "
hexmask.long.byte 0x58 8.--15. 1. "  [89] , "
hexmask.long.byte 0x58 16.--23. 1. "  [90] , "
hexmask.long.byte 0x58 24.--31. 1. "  [91] , "
hexmask.long.byte 0x5c 0.--7. 1. "  [92] , "
hexmask.long.byte 0x5c 8.--15. 1. "  [93] , "
hexmask.long.byte 0x5c 16.--23. 1. "  [94] , "
hexmask.long.byte 0x5c 24.--31. 1. "  [95] , "
hexmask.long.byte 0x60 0.--7. 1. "  [96] , "
hexmask.long.byte 0x60 8.--15. 1. "  [97] , "
hexmask.long.byte 0x60 16.--23. 1. "  [98] , "
hexmask.long.byte 0x60 24.--31. 1. "  [99] , "
hexmask.long.byte 0x64 0.--7. 1. "  [100] , "
hexmask.long.byte 0x64 8.--15. 1. "  [101] , "
hexmask.long.byte 0x64 16.--23. 1. "  [102] , "
hexmask.long.byte 0x64 24.--31. 1. "  [103] , "
hexmask.long.byte 0x68 0.--7. 1. "  [104] , "
hexmask.long.byte 0x68 8.--15. 1. "  [105] , "
hexmask.long.byte 0x68 16.--23. 1. "  [106] , "
hexmask.long.byte 0x68 24.--31. 1. "  [107] , "
hexmask.long.byte 0x6c 0.--7. 1. "  [108] , "
hexmask.long.byte 0x6c 8.--15. 1. "  [109] , "
hexmask.long.byte 0x6c 16.--23. 1. "  [110] , "
hexmask.long.byte 0x6c 24.--31. 1. "  [111] , "
hexmask.long.byte 0x70 0.--7. 1. "  [112] , "
hexmask.long.byte 0x70 8.--15. 1. "  [113] , "
hexmask.long.byte 0x70 16.--23. 1. "  [114] , "
hexmask.long.byte 0x70 24.--31. 1. "  [115] , "
hexmask.long.byte 0x74 0.--7. 1. "  [116] , "
hexmask.long.byte 0x74 8.--15. 1. "  [117] , "
hexmask.long.byte 0x74 16.--23. 1. "  [118] , "
hexmask.long.byte 0x74 24.--31. 1. "  [119] , "
hexmask.long.byte 0x78 0.--7. 1. "  [120] , "
hexmask.long.byte 0x78 8.--15. 1. "  [121] , "
hexmask.long.byte 0x78 16.--23. 1. "  [122] , "
hexmask.long.byte 0x78 24.--31. 1. "  [123] , "
hexmask.long.byte 0x7c 0.--7. 1. "  [124] , "
hexmask.long.byte 0x7c 8.--15. 1. "  [125] , "
hexmask.long.byte 0x7c 16.--23. 1. "  [126] , "
hexmask.long.byte 0x7c 24.--31. 1. "  [127] , "
TREE.END
TREE "Noise Profile Frame Stitch LUT M"
group.long 0xfc00++0x80
line.quad 0x00 "0xfc00"
hexmask.long.byte 0x0 0.--7. 1. " Weight lut[0]             , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.long.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.long.byte 0x4 8.--15. 1. "  [5]  , "
hexmask.long.byte 0x4 16.--23. 1. "  [6]  , "
hexmask.long.byte 0x4 24.--31. 1. "  [7]  , "
hexmask.long.byte 0x8 0.--7. 1. "  [8]  , "
hexmask.long.byte 0x8 8.--15. 1. "  [9]  , "
hexmask.long.byte 0x8 16.--23. 1. "  [10] , "
hexmask.long.byte 0x8 24.--31. 1. "  [11] , "
hexmask.long.byte 0xc 0.--7. 1. "  [12] , "
hexmask.long.byte 0xc 8.--15. 1. "  [13] , "
hexmask.long.byte 0xc 16.--23. 1. "  [14] , "
hexmask.long.byte 0xc 24.--31. 1. "  [15] , "
hexmask.long.byte 0x10 0.--7. 1. "  [16] , "
hexmask.long.byte 0x10 8.--15. 1. "  [17] , "
hexmask.long.byte 0x10 16.--23. 1. "  [18] , "
hexmask.long.byte 0x10 24.--31. 1. "  [19] , "
hexmask.long.byte 0x14 0.--7. 1. "  [20] , "
hexmask.long.byte 0x14 8.--15. 1. "  [21] , "
hexmask.long.byte 0x14 16.--23. 1. "  [22] , "
hexmask.long.byte 0x14 24.--31. 1. "  [23] , "
hexmask.long.byte 0x18 0.--7. 1. "  [24] , "
hexmask.long.byte 0x18 8.--15. 1. "  [25] , "
hexmask.long.byte 0x18 16.--23. 1. "  [26] , "
hexmask.long.byte 0x18 24.--31. 1. "  [27] , "
hexmask.long.byte 0x1c 0.--7. 1. "  [28] , "
hexmask.long.byte 0x1c 8.--15. 1. "  [29] , "
hexmask.long.byte 0x1c 16.--23. 1. "  [30] , "
hexmask.long.byte 0x1c 24.--31. 1. "  [31] , "
hexmask.long.byte 0x20 0.--7. 1. "  [32] , "
hexmask.long.byte 0x20 8.--15. 1. "  [33] , "
hexmask.long.byte 0x20 16.--23. 1. "  [34] , "
hexmask.long.byte 0x20 24.--31. 1. "  [35] , "
hexmask.long.byte 0x24 0.--7. 1. "  [36] , "
hexmask.long.byte 0x24 8.--15. 1. "  [37] , "
hexmask.long.byte 0x24 16.--23. 1. "  [38] , "
hexmask.long.byte 0x24 24.--31. 1. "  [39] , "
hexmask.long.byte 0x28 0.--7. 1. "  [40] , "
hexmask.long.byte 0x28 8.--15. 1. "  [41] , "
hexmask.long.byte 0x28 16.--23. 1. "  [42] , "
hexmask.long.byte 0x28 24.--31. 1. "  [43] , "
hexmask.long.byte 0x2c 0.--7. 1. "  [44] , "
hexmask.long.byte 0x2c 8.--15. 1. "  [45] , "
hexmask.long.byte 0x2c 16.--23. 1. "  [46] , "
hexmask.long.byte 0x2c 24.--31. 1. "  [47] , "
hexmask.long.byte 0x30 0.--7. 1. "  [48] , "
hexmask.long.byte 0x30 8.--15. 1. "  [49] , "
hexmask.long.byte 0x30 16.--23. 1. "  [50] , "
hexmask.long.byte 0x30 24.--31. 1. "  [51] , "
hexmask.long.byte 0x34 0.--7. 1. "  [52] , "
hexmask.long.byte 0x34 8.--15. 1. "  [53] , "
hexmask.long.byte 0x34 16.--23. 1. "  [54] , "
hexmask.long.byte 0x34 24.--31. 1. "  [55] , "
hexmask.long.byte 0x38 0.--7. 1. "  [56] , "
hexmask.long.byte 0x38 8.--15. 1. "  [57] , "
hexmask.long.byte 0x38 16.--23. 1. "  [58] , "
hexmask.long.byte 0x38 24.--31. 1. "  [59] , "
hexmask.long.byte 0x3c 0.--7. 1. "  [60] , "
hexmask.long.byte 0x3c 8.--15. 1. "  [61] , "
hexmask.long.byte 0x3c 16.--23. 1. "  [62] , "
hexmask.long.byte 0x3c 24.--31. 1. "  [63] , "
hexmask.long.byte 0x40 0.--7. 1. "  [64] , "
hexmask.long.byte 0x40 8.--15. 1. "  [65] , "
hexmask.long.byte 0x40 16.--23. 1. "  [66] , "
hexmask.long.byte 0x40 24.--31. 1. "  [67] , "
hexmask.long.byte 0x44 0.--7. 1. "  [68] , "
hexmask.long.byte 0x44 8.--15. 1. "  [69] , "
hexmask.long.byte 0x44 16.--23. 1. "  [70] , "
hexmask.long.byte 0x44 24.--31. 1. "  [71] , "
hexmask.long.byte 0x48 0.--7. 1. "  [72] , "
hexmask.long.byte 0x48 8.--15. 1. "  [73] , "
hexmask.long.byte 0x48 16.--23. 1. "  [74] , "
hexmask.long.byte 0x48 24.--31. 1. "  [75] , "
hexmask.long.byte 0x4c 0.--7. 1. "  [76] , "
hexmask.long.byte 0x4c 8.--15. 1. "  [77] , "
hexmask.long.byte 0x4c 16.--23. 1. "  [78] , "
hexmask.long.byte 0x4c 24.--31. 1. "  [79] , "
hexmask.long.byte 0x50 0.--7. 1. "  [80] , "
hexmask.long.byte 0x50 8.--15. 1. "  [81] , "
hexmask.long.byte 0x50 16.--23. 1. "  [82] , "
hexmask.long.byte 0x50 24.--31. 1. "  [83] , "
hexmask.long.byte 0x54 0.--7. 1. "  [84] , "
hexmask.long.byte 0x54 8.--15. 1. "  [85] , "
hexmask.long.byte 0x54 16.--23. 1. "  [86] , "
hexmask.long.byte 0x54 24.--31. 1. "  [87] , "
hexmask.long.byte 0x58 0.--7. 1. "  [88] , "
hexmask.long.byte 0x58 8.--15. 1. "  [89] , "
hexmask.long.byte 0x58 16.--23. 1. "  [90] , "
hexmask.long.byte 0x58 24.--31. 1. "  [91] , "
hexmask.long.byte 0x5c 0.--7. 1. "  [92] , "
hexmask.long.byte 0x5c 8.--15. 1. "  [93] , "
hexmask.long.byte 0x5c 16.--23. 1. "  [94] , "
hexmask.long.byte 0x5c 24.--31. 1. "  [95] , "
hexmask.long.byte 0x60 0.--7. 1. "  [96] , "
hexmask.long.byte 0x60 8.--15. 1. "  [97] , "
hexmask.long.byte 0x60 16.--23. 1. "  [98] , "
hexmask.long.byte 0x60 24.--31. 1. "  [99] , "
hexmask.long.byte 0x64 0.--7. 1. "  [100] , "
hexmask.long.byte 0x64 8.--15. 1. "  [101] , "
hexmask.long.byte 0x64 16.--23. 1. "  [102] , "
hexmask.long.byte 0x64 24.--31. 1. "  [103] , "
hexmask.long.byte 0x68 0.--7. 1. "  [104] , "
hexmask.long.byte 0x68 8.--15. 1. "  [105] , "
hexmask.long.byte 0x68 16.--23. 1. "  [106] , "
hexmask.long.byte 0x68 24.--31. 1. "  [107] , "
hexmask.long.byte 0x6c 0.--7. 1. "  [108] , "
hexmask.long.byte 0x6c 8.--15. 1. "  [109] , "
hexmask.long.byte 0x6c 16.--23. 1. "  [110] , "
hexmask.long.byte 0x6c 24.--31. 1. "  [111] , "
hexmask.long.byte 0x70 0.--7. 1. "  [112] , "
hexmask.long.byte 0x70 8.--15. 1. "  [113] , "
hexmask.long.byte 0x70 16.--23. 1. "  [114] , "
hexmask.long.byte 0x70 24.--31. 1. "  [115] , "
hexmask.long.byte 0x74 0.--7. 1. "  [116] , "
hexmask.long.byte 0x74 8.--15. 1. "  [117] , "
hexmask.long.byte 0x74 16.--23. 1. "  [118] , "
hexmask.long.byte 0x74 24.--31. 1. "  [119] , "
hexmask.long.byte 0x78 0.--7. 1. "  [120] , "
hexmask.long.byte 0x78 8.--15. 1. "  [121] , "
hexmask.long.byte 0x78 16.--23. 1. "  [122] , "
hexmask.long.byte 0x78 24.--31. 1. "  [123] , "
hexmask.long.byte 0x7c 0.--7. 1. "  [124] , "
hexmask.long.byte 0x7c 8.--15. 1. "  [125] , "
hexmask.long.byte 0x7c 16.--23. 1. "  [126] , "
hexmask.long.byte 0x7c 24.--31. 1. "  [127] , "
TREE.END
TREE "Noise Profile Frame Stitch LUT L"
group.long 0xfc80++0x80
line.quad 0x00 "0xfc80"
hexmask.long.byte 0x0 0.--7. 1. " Weight lut[0]             , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.long.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.long.byte 0x4 8.--15. 1. "  [5]  , "
hexmask.long.byte 0x4 16.--23. 1. "  [6]  , "
hexmask.long.byte 0x4 24.--31. 1. "  [7]  , "
hexmask.long.byte 0x8 0.--7. 1. "  [8]  , "
hexmask.long.byte 0x8 8.--15. 1. "  [9]  , "
hexmask.long.byte 0x8 16.--23. 1. "  [10] , "
hexmask.long.byte 0x8 24.--31. 1. "  [11] , "
hexmask.long.byte 0xc 0.--7. 1. "  [12] , "
hexmask.long.byte 0xc 8.--15. 1. "  [13] , "
hexmask.long.byte 0xc 16.--23. 1. "  [14] , "
hexmask.long.byte 0xc 24.--31. 1. "  [15] , "
hexmask.long.byte 0x10 0.--7. 1. "  [16] , "
hexmask.long.byte 0x10 8.--15. 1. "  [17] , "
hexmask.long.byte 0x10 16.--23. 1. "  [18] , "
hexmask.long.byte 0x10 24.--31. 1. "  [19] , "
hexmask.long.byte 0x14 0.--7. 1. "  [20] , "
hexmask.long.byte 0x14 8.--15. 1. "  [21] , "
hexmask.long.byte 0x14 16.--23. 1. "  [22] , "
hexmask.long.byte 0x14 24.--31. 1. "  [23] , "
hexmask.long.byte 0x18 0.--7. 1. "  [24] , "
hexmask.long.byte 0x18 8.--15. 1. "  [25] , "
hexmask.long.byte 0x18 16.--23. 1. "  [26] , "
hexmask.long.byte 0x18 24.--31. 1. "  [27] , "
hexmask.long.byte 0x1c 0.--7. 1. "  [28] , "
hexmask.long.byte 0x1c 8.--15. 1. "  [29] , "
hexmask.long.byte 0x1c 16.--23. 1. "  [30] , "
hexmask.long.byte 0x1c 24.--31. 1. "  [31] , "
hexmask.long.byte 0x20 0.--7. 1. "  [32] , "
hexmask.long.byte 0x20 8.--15. 1. "  [33] , "
hexmask.long.byte 0x20 16.--23. 1. "  [34] , "
hexmask.long.byte 0x20 24.--31. 1. "  [35] , "
hexmask.long.byte 0x24 0.--7. 1. "  [36] , "
hexmask.long.byte 0x24 8.--15. 1. "  [37] , "
hexmask.long.byte 0x24 16.--23. 1. "  [38] , "
hexmask.long.byte 0x24 24.--31. 1. "  [39] , "
hexmask.long.byte 0x28 0.--7. 1. "  [40] , "
hexmask.long.byte 0x28 8.--15. 1. "  [41] , "
hexmask.long.byte 0x28 16.--23. 1. "  [42] , "
hexmask.long.byte 0x28 24.--31. 1. "  [43] , "
hexmask.long.byte 0x2c 0.--7. 1. "  [44] , "
hexmask.long.byte 0x2c 8.--15. 1. "  [45] , "
hexmask.long.byte 0x2c 16.--23. 1. "  [46] , "
hexmask.long.byte 0x2c 24.--31. 1. "  [47] , "
hexmask.long.byte 0x30 0.--7. 1. "  [48] , "
hexmask.long.byte 0x30 8.--15. 1. "  [49] , "
hexmask.long.byte 0x30 16.--23. 1. "  [50] , "
hexmask.long.byte 0x30 24.--31. 1. "  [51] , "
hexmask.long.byte 0x34 0.--7. 1. "  [52] , "
hexmask.long.byte 0x34 8.--15. 1. "  [53] , "
hexmask.long.byte 0x34 16.--23. 1. "  [54] , "
hexmask.long.byte 0x34 24.--31. 1. "  [55] , "
hexmask.long.byte 0x38 0.--7. 1. "  [56] , "
hexmask.long.byte 0x38 8.--15. 1. "  [57] , "
hexmask.long.byte 0x38 16.--23. 1. "  [58] , "
hexmask.long.byte 0x38 24.--31. 1. "  [59] , "
hexmask.long.byte 0x3c 0.--7. 1. "  [60] , "
hexmask.long.byte 0x3c 8.--15. 1. "  [61] , "
hexmask.long.byte 0x3c 16.--23. 1. "  [62] , "
hexmask.long.byte 0x3c 24.--31. 1. "  [63] , "
hexmask.long.byte 0x40 0.--7. 1. "  [64] , "
hexmask.long.byte 0x40 8.--15. 1. "  [65] , "
hexmask.long.byte 0x40 16.--23. 1. "  [66] , "
hexmask.long.byte 0x40 24.--31. 1. "  [67] , "
hexmask.long.byte 0x44 0.--7. 1. "  [68] , "
hexmask.long.byte 0x44 8.--15. 1. "  [69] , "
hexmask.long.byte 0x44 16.--23. 1. "  [70] , "
hexmask.long.byte 0x44 24.--31. 1. "  [71] , "
hexmask.long.byte 0x48 0.--7. 1. "  [72] , "
hexmask.long.byte 0x48 8.--15. 1. "  [73] , "
hexmask.long.byte 0x48 16.--23. 1. "  [74] , "
hexmask.long.byte 0x48 24.--31. 1. "  [75] , "
hexmask.long.byte 0x4c 0.--7. 1. "  [76] , "
hexmask.long.byte 0x4c 8.--15. 1. "  [77] , "
hexmask.long.byte 0x4c 16.--23. 1. "  [78] , "
hexmask.long.byte 0x4c 24.--31. 1. "  [79] , "
hexmask.long.byte 0x50 0.--7. 1. "  [80] , "
hexmask.long.byte 0x50 8.--15. 1. "  [81] , "
hexmask.long.byte 0x50 16.--23. 1. "  [82] , "
hexmask.long.byte 0x50 24.--31. 1. "  [83] , "
hexmask.long.byte 0x54 0.--7. 1. "  [84] , "
hexmask.long.byte 0x54 8.--15. 1. "  [85] , "
hexmask.long.byte 0x54 16.--23. 1. "  [86] , "
hexmask.long.byte 0x54 24.--31. 1. "  [87] , "
hexmask.long.byte 0x58 0.--7. 1. "  [88] , "
hexmask.long.byte 0x58 8.--15. 1. "  [89] , "
hexmask.long.byte 0x58 16.--23. 1. "  [90] , "
hexmask.long.byte 0x58 24.--31. 1. "  [91] , "
hexmask.long.byte 0x5c 0.--7. 1. "  [92] , "
hexmask.long.byte 0x5c 8.--15. 1. "  [93] , "
hexmask.long.byte 0x5c 16.--23. 1. "  [94] , "
hexmask.long.byte 0x5c 24.--31. 1. "  [95] , "
hexmask.long.byte 0x60 0.--7. 1. "  [96] , "
hexmask.long.byte 0x60 8.--15. 1. "  [97] , "
hexmask.long.byte 0x60 16.--23. 1. "  [98] , "
hexmask.long.byte 0x60 24.--31. 1. "  [99] , "
hexmask.long.byte 0x64 0.--7. 1. "  [100] , "
hexmask.long.byte 0x64 8.--15. 1. "  [101] , "
hexmask.long.byte 0x64 16.--23. 1. "  [102] , "
hexmask.long.byte 0x64 24.--31. 1. "  [103] , "
hexmask.long.byte 0x68 0.--7. 1. "  [104] , "
hexmask.long.byte 0x68 8.--15. 1. "  [105] , "
hexmask.long.byte 0x68 16.--23. 1. "  [106] , "
hexmask.long.byte 0x68 24.--31. 1. "  [107] , "
hexmask.long.byte 0x6c 0.--7. 1. "  [108] , "
hexmask.long.byte 0x6c 8.--15. 1. "  [109] , "
hexmask.long.byte 0x6c 16.--23. 1. "  [110] , "
hexmask.long.byte 0x6c 24.--31. 1. "  [111] , "
hexmask.long.byte 0x70 0.--7. 1. "  [112] , "
hexmask.long.byte 0x70 8.--15. 1. "  [113] , "
hexmask.long.byte 0x70 16.--23. 1. "  [114] , "
hexmask.long.byte 0x70 24.--31. 1. "  [115] , "
hexmask.long.byte 0x74 0.--7. 1. "  [116] , "
hexmask.long.byte 0x74 8.--15. 1. "  [117] , "
hexmask.long.byte 0x74 16.--23. 1. "  [118] , "
hexmask.long.byte 0x74 24.--31. 1. "  [119] , "
hexmask.long.byte 0x78 0.--7. 1. "  [120] , "
hexmask.long.byte 0x78 8.--15. 1. "  [121] , "
hexmask.long.byte 0x78 16.--23. 1. "  [122] , "
hexmask.long.byte 0x78 24.--31. 1. "  [123] , "
hexmask.long.byte 0x7c 0.--7. 1. "  [124] , "
hexmask.long.byte 0x7c 8.--15. 1. "  [125] , "
hexmask.long.byte 0x7c 16.--23. 1. "  [126] , "
hexmask.long.byte 0x7c 24.--31. 1. "  [127] , "
TREE.END
TREE "Noise Profile LUT"
group.long 0xfd00++0x80
line.quad 0x00 "0xfd00"
hexmask.long.byte 0x0 0.--7. 1. " Weight lut[0]             , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.long.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.long.byte 0x4 8.--15. 1. "  [5]  , "
hexmask.long.byte 0x4 16.--23. 1. "  [6]  , "
hexmask.long.byte 0x4 24.--31. 1. "  [7]  , "
hexmask.long.byte 0x8 0.--7. 1. "  [8]  , "
hexmask.long.byte 0x8 8.--15. 1. "  [9]  , "
hexmask.long.byte 0x8 16.--23. 1. "  [10] , "
hexmask.long.byte 0x8 24.--31. 1. "  [11] , "
hexmask.long.byte 0xc 0.--7. 1. "  [12] , "
hexmask.long.byte 0xc 8.--15. 1. "  [13] , "
hexmask.long.byte 0xc 16.--23. 1. "  [14] , "
hexmask.long.byte 0xc 24.--31. 1. "  [15] , "
hexmask.long.byte 0x10 0.--7. 1. "  [16] , "
hexmask.long.byte 0x10 8.--15. 1. "  [17] , "
hexmask.long.byte 0x10 16.--23. 1. "  [18] , "
hexmask.long.byte 0x10 24.--31. 1. "  [19] , "
hexmask.long.byte 0x14 0.--7. 1. "  [20] , "
hexmask.long.byte 0x14 8.--15. 1. "  [21] , "
hexmask.long.byte 0x14 16.--23. 1. "  [22] , "
hexmask.long.byte 0x14 24.--31. 1. "  [23] , "
hexmask.long.byte 0x18 0.--7. 1. "  [24] , "
hexmask.long.byte 0x18 8.--15. 1. "  [25] , "
hexmask.long.byte 0x18 16.--23. 1. "  [26] , "
hexmask.long.byte 0x18 24.--31. 1. "  [27] , "
hexmask.long.byte 0x1c 0.--7. 1. "  [28] , "
hexmask.long.byte 0x1c 8.--15. 1. "  [29] , "
hexmask.long.byte 0x1c 16.--23. 1. "  [30] , "
hexmask.long.byte 0x1c 24.--31. 1. "  [31] , "
hexmask.long.byte 0x20 0.--7. 1. "  [32] , "
hexmask.long.byte 0x20 8.--15. 1. "  [33] , "
hexmask.long.byte 0x20 16.--23. 1. "  [34] , "
hexmask.long.byte 0x20 24.--31. 1. "  [35] , "
hexmask.long.byte 0x24 0.--7. 1. "  [36] , "
hexmask.long.byte 0x24 8.--15. 1. "  [37] , "
hexmask.long.byte 0x24 16.--23. 1. "  [38] , "
hexmask.long.byte 0x24 24.--31. 1. "  [39] , "
hexmask.long.byte 0x28 0.--7. 1. "  [40] , "
hexmask.long.byte 0x28 8.--15. 1. "  [41] , "
hexmask.long.byte 0x28 16.--23. 1. "  [42] , "
hexmask.long.byte 0x28 24.--31. 1. "  [43] , "
hexmask.long.byte 0x2c 0.--7. 1. "  [44] , "
hexmask.long.byte 0x2c 8.--15. 1. "  [45] , "
hexmask.long.byte 0x2c 16.--23. 1. "  [46] , "
hexmask.long.byte 0x2c 24.--31. 1. "  [47] , "
hexmask.long.byte 0x30 0.--7. 1. "  [48] , "
hexmask.long.byte 0x30 8.--15. 1. "  [49] , "
hexmask.long.byte 0x30 16.--23. 1. "  [50] , "
hexmask.long.byte 0x30 24.--31. 1. "  [51] , "
hexmask.long.byte 0x34 0.--7. 1. "  [52] , "
hexmask.long.byte 0x34 8.--15. 1. "  [53] , "
hexmask.long.byte 0x34 16.--23. 1. "  [54] , "
hexmask.long.byte 0x34 24.--31. 1. "  [55] , "
hexmask.long.byte 0x38 0.--7. 1. "  [56] , "
hexmask.long.byte 0x38 8.--15. 1. "  [57] , "
hexmask.long.byte 0x38 16.--23. 1. "  [58] , "
hexmask.long.byte 0x38 24.--31. 1. "  [59] , "
hexmask.long.byte 0x3c 0.--7. 1. "  [60] , "
hexmask.long.byte 0x3c 8.--15. 1. "  [61] , "
hexmask.long.byte 0x3c 16.--23. 1. "  [62] , "
hexmask.long.byte 0x3c 24.--31. 1. "  [63] , "
hexmask.long.byte 0x40 0.--7. 1. "  [64] , "
hexmask.long.byte 0x40 8.--15. 1. "  [65] , "
hexmask.long.byte 0x40 16.--23. 1. "  [66] , "
hexmask.long.byte 0x40 24.--31. 1. "  [67] , "
hexmask.long.byte 0x44 0.--7. 1. "  [68] , "
hexmask.long.byte 0x44 8.--15. 1. "  [69] , "
hexmask.long.byte 0x44 16.--23. 1. "  [70] , "
hexmask.long.byte 0x44 24.--31. 1. "  [71] , "
hexmask.long.byte 0x48 0.--7. 1. "  [72] , "
hexmask.long.byte 0x48 8.--15. 1. "  [73] , "
hexmask.long.byte 0x48 16.--23. 1. "  [74] , "
hexmask.long.byte 0x48 24.--31. 1. "  [75] , "
hexmask.long.byte 0x4c 0.--7. 1. "  [76] , "
hexmask.long.byte 0x4c 8.--15. 1. "  [77] , "
hexmask.long.byte 0x4c 16.--23. 1. "  [78] , "
hexmask.long.byte 0x4c 24.--31. 1. "  [79] , "
hexmask.long.byte 0x50 0.--7. 1. "  [80] , "
hexmask.long.byte 0x50 8.--15. 1. "  [81] , "
hexmask.long.byte 0x50 16.--23. 1. "  [82] , "
hexmask.long.byte 0x50 24.--31. 1. "  [83] , "
hexmask.long.byte 0x54 0.--7. 1. "  [84] , "
hexmask.long.byte 0x54 8.--15. 1. "  [85] , "
hexmask.long.byte 0x54 16.--23. 1. "  [86] , "
hexmask.long.byte 0x54 24.--31. 1. "  [87] , "
hexmask.long.byte 0x58 0.--7. 1. "  [88] , "
hexmask.long.byte 0x58 8.--15. 1. "  [89] , "
hexmask.long.byte 0x58 16.--23. 1. "  [90] , "
hexmask.long.byte 0x58 24.--31. 1. "  [91] , "
hexmask.long.byte 0x5c 0.--7. 1. "  [92] , "
hexmask.long.byte 0x5c 8.--15. 1. "  [93] , "
hexmask.long.byte 0x5c 16.--23. 1. "  [94] , "
hexmask.long.byte 0x5c 24.--31. 1. "  [95] , "
hexmask.long.byte 0x60 0.--7. 1. "  [96] , "
hexmask.long.byte 0x60 8.--15. 1. "  [97] , "
hexmask.long.byte 0x60 16.--23. 1. "  [98] , "
hexmask.long.byte 0x60 24.--31. 1. "  [99] , "
hexmask.long.byte 0x64 0.--7. 1. "  [100] , "
hexmask.long.byte 0x64 8.--15. 1. "  [101] , "
hexmask.long.byte 0x64 16.--23. 1. "  [102] , "
hexmask.long.byte 0x64 24.--31. 1. "  [103] , "
hexmask.long.byte 0x68 0.--7. 1. "  [104] , "
hexmask.long.byte 0x68 8.--15. 1. "  [105] , "
hexmask.long.byte 0x68 16.--23. 1. "  [106] , "
hexmask.long.byte 0x68 24.--31. 1. "  [107] , "
hexmask.long.byte 0x6c 0.--7. 1. "  [108] , "
hexmask.long.byte 0x6c 8.--15. 1. "  [109] , "
hexmask.long.byte 0x6c 16.--23. 1. "  [110] , "
hexmask.long.byte 0x6c 24.--31. 1. "  [111] , "
hexmask.long.byte 0x70 0.--7. 1. "  [112] , "
hexmask.long.byte 0x70 8.--15. 1. "  [113] , "
hexmask.long.byte 0x70 16.--23. 1. "  [114] , "
hexmask.long.byte 0x70 24.--31. 1. "  [115] , "
hexmask.long.byte 0x74 0.--7. 1. "  [116] , "
hexmask.long.byte 0x74 8.--15. 1. "  [117] , "
hexmask.long.byte 0x74 16.--23. 1. "  [118] , "
hexmask.long.byte 0x74 24.--31. 1. "  [119] , "
hexmask.long.byte 0x78 0.--7. 1. "  [120] , "
hexmask.long.byte 0x78 8.--15. 1. "  [121] , "
hexmask.long.byte 0x78 16.--23. 1. "  [122] , "
hexmask.long.byte 0x78 24.--31. 1. "  [123] , "
hexmask.long.byte 0x7c 0.--7. 1. "  [124] , "
hexmask.long.byte 0x7c 8.--15. 1. "  [125] , "
hexmask.long.byte 0x7c 16.--23. 1. "  [126] , "
hexmask.long.byte 0x7c 24.--31. 1. "  [127] , "
TREE.END
TREE "Noise Profile Demosaic LUT"
group.long 0xfd80++0x80
line.quad 0x00 "0xfd80"
hexmask.long.byte 0x0 0.--7. 1. " Weight lut[0]             , "
hexmask.long.byte 0x0 8.--15. 1. "  [1]  , "
hexmask.long.byte 0x0 16.--23. 1. "  [2]  , "
hexmask.long.byte 0x0 24.--31. 1. "  [3]  , "
hexmask.long.byte 0x4 0.--7. 1. "  [4]  , "
hexmask.long.byte 0x4 8.--15. 1. "  [5]  , "
hexmask.long.byte 0x4 16.--23. 1. "  [6]  , "
hexmask.long.byte 0x4 24.--31. 1. "  [7]  , "
hexmask.long.byte 0x8 0.--7. 1. "  [8]  , "
hexmask.long.byte 0x8 8.--15. 1. "  [9]  , "
hexmask.long.byte 0x8 16.--23. 1. "  [10] , "
hexmask.long.byte 0x8 24.--31. 1. "  [11] , "
hexmask.long.byte 0xc 0.--7. 1. "  [12] , "
hexmask.long.byte 0xc 8.--15. 1. "  [13] , "
hexmask.long.byte 0xc 16.--23. 1. "  [14] , "
hexmask.long.byte 0xc 24.--31. 1. "  [15] , "
hexmask.long.byte 0x10 0.--7. 1. "  [16] , "
hexmask.long.byte 0x10 8.--15. 1. "  [17] , "
hexmask.long.byte 0x10 16.--23. 1. "  [18] , "
hexmask.long.byte 0x10 24.--31. 1. "  [19] , "
hexmask.long.byte 0x14 0.--7. 1. "  [20] , "
hexmask.long.byte 0x14 8.--15. 1. "  [21] , "
hexmask.long.byte 0x14 16.--23. 1. "  [22] , "
hexmask.long.byte 0x14 24.--31. 1. "  [23] , "
hexmask.long.byte 0x18 0.--7. 1. "  [24] , "
hexmask.long.byte 0x18 8.--15. 1. "  [25] , "
hexmask.long.byte 0x18 16.--23. 1. "  [26] , "
hexmask.long.byte 0x18 24.--31. 1. "  [27] , "
hexmask.long.byte 0x1c 0.--7. 1. "  [28] , "
hexmask.long.byte 0x1c 8.--15. 1. "  [29] , "
hexmask.long.byte 0x1c 16.--23. 1. "  [30] , "
hexmask.long.byte 0x1c 24.--31. 1. "  [31] , "
hexmask.long.byte 0x20 0.--7. 1. "  [32] , "
hexmask.long.byte 0x20 8.--15. 1. "  [33] , "
hexmask.long.byte 0x20 16.--23. 1. "  [34] , "
hexmask.long.byte 0x20 24.--31. 1. "  [35] , "
hexmask.long.byte 0x24 0.--7. 1. "  [36] , "
hexmask.long.byte 0x24 8.--15. 1. "  [37] , "
hexmask.long.byte 0x24 16.--23. 1. "  [38] , "
hexmask.long.byte 0x24 24.--31. 1. "  [39] , "
hexmask.long.byte 0x28 0.--7. 1. "  [40] , "
hexmask.long.byte 0x28 8.--15. 1. "  [41] , "
hexmask.long.byte 0x28 16.--23. 1. "  [42] , "
hexmask.long.byte 0x28 24.--31. 1. "  [43] , "
hexmask.long.byte 0x2c 0.--7. 1. "  [44] , "
hexmask.long.byte 0x2c 8.--15. 1. "  [45] , "
hexmask.long.byte 0x2c 16.--23. 1. "  [46] , "
hexmask.long.byte 0x2c 24.--31. 1. "  [47] , "
hexmask.long.byte 0x30 0.--7. 1. "  [48] , "
hexmask.long.byte 0x30 8.--15. 1. "  [49] , "
hexmask.long.byte 0x30 16.--23. 1. "  [50] , "
hexmask.long.byte 0x30 24.--31. 1. "  [51] , "
hexmask.long.byte 0x34 0.--7. 1. "  [52] , "
hexmask.long.byte 0x34 8.--15. 1. "  [53] , "
hexmask.long.byte 0x34 16.--23. 1. "  [54] , "
hexmask.long.byte 0x34 24.--31. 1. "  [55] , "
hexmask.long.byte 0x38 0.--7. 1. "  [56] , "
hexmask.long.byte 0x38 8.--15. 1. "  [57] , "
hexmask.long.byte 0x38 16.--23. 1. "  [58] , "
hexmask.long.byte 0x38 24.--31. 1. "  [59] , "
hexmask.long.byte 0x3c 0.--7. 1. "  [60] , "
hexmask.long.byte 0x3c 8.--15. 1. "  [61] , "
hexmask.long.byte 0x3c 16.--23. 1. "  [62] , "
hexmask.long.byte 0x3c 24.--31. 1. "  [63] , "
hexmask.long.byte 0x40 0.--7. 1. "  [64] , "
hexmask.long.byte 0x40 8.--15. 1. "  [65] , "
hexmask.long.byte 0x40 16.--23. 1. "  [66] , "
hexmask.long.byte 0x40 24.--31. 1. "  [67] , "
hexmask.long.byte 0x44 0.--7. 1. "  [68] , "
hexmask.long.byte 0x44 8.--15. 1. "  [69] , "
hexmask.long.byte 0x44 16.--23. 1. "  [70] , "
hexmask.long.byte 0x44 24.--31. 1. "  [71] , "
hexmask.long.byte 0x48 0.--7. 1. "  [72] , "
hexmask.long.byte 0x48 8.--15. 1. "  [73] , "
hexmask.long.byte 0x48 16.--23. 1. "  [74] , "
hexmask.long.byte 0x48 24.--31. 1. "  [75] , "
hexmask.long.byte 0x4c 0.--7. 1. "  [76] , "
hexmask.long.byte 0x4c 8.--15. 1. "  [77] , "
hexmask.long.byte 0x4c 16.--23. 1. "  [78] , "
hexmask.long.byte 0x4c 24.--31. 1. "  [79] , "
hexmask.long.byte 0x50 0.--7. 1. "  [80] , "
hexmask.long.byte 0x50 8.--15. 1. "  [81] , "
hexmask.long.byte 0x50 16.--23. 1. "  [82] , "
hexmask.long.byte 0x50 24.--31. 1. "  [83] , "
hexmask.long.byte 0x54 0.--7. 1. "  [84] , "
hexmask.long.byte 0x54 8.--15. 1. "  [85] , "
hexmask.long.byte 0x54 16.--23. 1. "  [86] , "
hexmask.long.byte 0x54 24.--31. 1. "  [87] , "
hexmask.long.byte 0x58 0.--7. 1. "  [88] , "
hexmask.long.byte 0x58 8.--15. 1. "  [89] , "
hexmask.long.byte 0x58 16.--23. 1. "  [90] , "
hexmask.long.byte 0x58 24.--31. 1. "  [91] , "
hexmask.long.byte 0x5c 0.--7. 1. "  [92] , "
hexmask.long.byte 0x5c 8.--15. 1. "  [93] , "
hexmask.long.byte 0x5c 16.--23. 1. "  [94] , "
hexmask.long.byte 0x5c 24.--31. 1. "  [95] , "
hexmask.long.byte 0x60 0.--7. 1. "  [96] , "
hexmask.long.byte 0x60 8.--15. 1. "  [97] , "
hexmask.long.byte 0x60 16.--23. 1. "  [98] , "
hexmask.long.byte 0x60 24.--31. 1. "  [99] , "
hexmask.long.byte 0x64 0.--7. 1. "  [100] , "
hexmask.long.byte 0x64 8.--15. 1. "  [101] , "
hexmask.long.byte 0x64 16.--23. 1. "  [102] , "
hexmask.long.byte 0x64 24.--31. 1. "  [103] , "
hexmask.long.byte 0x68 0.--7. 1. "  [104] , "
hexmask.long.byte 0x68 8.--15. 1. "  [105] , "
hexmask.long.byte 0x68 16.--23. 1. "  [106] , "
hexmask.long.byte 0x68 24.--31. 1. "  [107] , "
hexmask.long.byte 0x6c 0.--7. 1. "  [108] , "
hexmask.long.byte 0x6c 8.--15. 1. "  [109] , "
hexmask.long.byte 0x6c 16.--23. 1. "  [110] , "
hexmask.long.byte 0x6c 24.--31. 1. "  [111] , "
hexmask.long.byte 0x70 0.--7. 1. "  [112] , "
hexmask.long.byte 0x70 8.--15. 1. "  [113] , "
hexmask.long.byte 0x70 16.--23. 1. "  [114] , "
hexmask.long.byte 0x70 24.--31. 1. "  [115] , "
hexmask.long.byte 0x74 0.--7. 1. "  [116] , "
hexmask.long.byte 0x74 8.--15. 1. "  [117] , "
hexmask.long.byte 0x74 16.--23. 1. "  [118] , "
hexmask.long.byte 0x74 24.--31. 1. "  [119] , "
hexmask.long.byte 0x78 0.--7. 1. "  [120] , "
hexmask.long.byte 0x78 8.--15. 1. "  [121] , "
hexmask.long.byte 0x78 16.--23. 1. "  [122] , "
hexmask.long.byte 0x78 24.--31. 1. "  [123] , "
hexmask.long.byte 0x7c 0.--7. 1. "  [124] , "
hexmask.long.byte 0x7c 8.--15. 1. "  [125] , "
hexmask.long.byte 0x7c 16.--23. 1. "  [126] , "
hexmask.long.byte 0x7c 24.--31. 1. "  [127] , "
TREE.END
TREE "Zones"
group.long 0xfe00++0xe5
line.quad 0x00 "0xfe00"
hexmask.long.byte 0x0 0.--3. 1. " AEXP Weight[0|0]          , "
hexmask.long.byte 0x0 8.--11. 1. "  [1|0] , "
hexmask.long.byte 0x0 16.--19. 1. "  [2|0] , "
hexmask.long.byte 0x0 24.--27. 1. "  [3|0] , "
hexmask.long.byte 0x4 0.--3. 1. "  [4|0] , "
hexmask.long.byte 0x4 8.--11. 1. "  [5|0] , "
hexmask.long.byte 0x4 16.--19. 1. "  [6|0] , "
hexmask.long.byte 0x4 24.--27. 1. "  [7|0] , "
hexmask.long.byte 0x8 0.--3. 1. "  [8|0] , "
hexmask.long.byte 0x8 8.--11. 1. "  [9|0] , "
hexmask.long.byte 0x8 16.--19. 1. "  [10|0] , "
hexmask.long.byte 0x8 24.--27. 1. "  [11|0] , "
hexmask.long.byte 0xc 0.--3. 1. "  [12|0] , "
hexmask.long.byte 0xc 8.--11. 1. "  [13|0] , "
hexmask.long.byte 0xc 16.--19. 1. "  [14|0] , "
line.quad 0x0f "0xfe0f"
hexmask.long.byte 0xc 24.--27. 1. " AEXP Weight[0|1]          , "
hexmask.long.byte 0x10 0.--3. 1. "  [1|1] , "
hexmask.long.byte 0x10 8.--11. 1. "  [2|1] , "
hexmask.long.byte 0x10 16.--19. 1. "  [3|1] , "
hexmask.long.byte 0x10 24.--27. 1. "  [4|1] , "
hexmask.long.byte 0x14 0.--3. 1. "  [5|1] , "
hexmask.long.byte 0x14 8.--11. 1. "  [6|1] , "
hexmask.long.byte 0x14 16.--19. 1. "  [7|1] , "
hexmask.long.byte 0x14 24.--27. 1. "  [8|1] , "
hexmask.long.byte 0x18 0.--3. 1. "  [9|1] , "
hexmask.long.byte 0x18 8.--11. 1. "  [10|1] , "
hexmask.long.byte 0x18 16.--19. 1. "  [11|1] , "
hexmask.long.byte 0x18 24.--27. 1. "  [12|1] , "
hexmask.long.byte 0x1c 0.--3. 1. "  [13|1] , "
hexmask.long.byte 0x1c 8.--11. 1. "  [14|1] , "
line.quad 0x1e "0xfe1e"
hexmask.long.byte 0x1c 16.--19. 1. " AEXP Weight[0|2]          , "
hexmask.long.byte 0x1c 24.--27. 1. "  [1|2] , "
hexmask.long.byte 0x20 0.--3. 1. "  [2|2] , "
hexmask.long.byte 0x20 8.--11. 1. "  [3|2] , "
hexmask.long.byte 0x20 16.--19. 1. "  [4|2] , "
hexmask.long.byte 0x20 24.--27. 1. "  [5|2] , "
hexmask.long.byte 0x24 0.--3. 1. "  [6|2] , "
hexmask.long.byte 0x24 8.--11. 1. "  [7|2] , "
hexmask.long.byte 0x24 16.--19. 1. "  [8|2] , "
hexmask.long.byte 0x24 24.--27. 1. "  [9|2] , "
hexmask.long.byte 0x28 0.--3. 1. "  [10|2] , "
hexmask.long.byte 0x28 8.--11. 1. "  [11|2] , "
hexmask.long.byte 0x28 16.--19. 1. "  [12|2] , "
hexmask.long.byte 0x28 24.--27. 1. "  [13|2] , "
hexmask.long.byte 0x2c 0.--3. 1. "  [14|2] , "
line.quad 0x2d "0xfe2d"
hexmask.long.byte 0x2c 8.--11. 1. " AEXP Weight[0|3]          , "
hexmask.long.byte 0x2c 16.--19. 1. "  [1|3] , "
hexmask.long.byte 0x2c 24.--27. 1. "  [2|3] , "
hexmask.long.byte 0x30 0.--3. 1. "  [3|3] , "
hexmask.long.byte 0x30 8.--11. 1. "  [4|3] , "
hexmask.long.byte 0x30 16.--19. 1. "  [5|3] , "
hexmask.long.byte 0x30 24.--27. 1. "  [6|3] , "
hexmask.long.byte 0x34 0.--3. 1. "  [7|3] , "
hexmask.long.byte 0x34 8.--11. 1. "  [8|3] , "
hexmask.long.byte 0x34 16.--19. 1. "  [9|3] , "
hexmask.long.byte 0x34 24.--27. 1. "  [10|3] , "
hexmask.long.byte 0x38 0.--3. 1. "  [11|3] , "
hexmask.long.byte 0x38 8.--11. 1. "  [12|3] , "
hexmask.long.byte 0x38 16.--19. 1. "  [13|3] , "
hexmask.long.byte 0x38 24.--27. 1. "  [14|3] , "
line.quad 0x3c "0xfe3c"
hexmask.long.byte 0x3c 0.--3. 1. " AEXP Weight[0|4]          , "
hexmask.long.byte 0x3c 8.--11. 1. "  [1|4] , "
hexmask.long.byte 0x3c 16.--19. 1. "  [2|4] , "
hexmask.long.byte 0x3c 24.--27. 1. "  [3|4] , "
hexmask.long.byte 0x40 0.--3. 1. "  [4|4] , "
hexmask.long.byte 0x40 8.--11. 1. "  [5|4] , "
hexmask.long.byte 0x40 16.--19. 1. "  [6|4] , "
hexmask.long.byte 0x40 24.--27. 1. "  [7|4] , "
hexmask.long.byte 0x44 0.--3. 1. "  [8|4] , "
hexmask.long.byte 0x44 8.--11. 1. "  [9|4] , "
hexmask.long.byte 0x44 16.--19. 1. "  [10|4] , "
hexmask.long.byte 0x44 24.--27. 1. "  [11|4] , "
hexmask.long.byte 0x48 0.--3. 1. "  [12|4] , "
hexmask.long.byte 0x48 8.--11. 1. "  [13|4] , "
hexmask.long.byte 0x48 16.--19. 1. "  [14|4] , "
line.quad 0x4b "0xfe4b"
hexmask.long.byte 0x48 24.--27. 1. " AEXP Weight[0|5]          , "
hexmask.long.byte 0x4c 0.--3. 1. "  [1|5] , "
hexmask.long.byte 0x4c 8.--11. 1. "  [2|5] , "
hexmask.long.byte 0x4c 16.--19. 1. "  [3|5] , "
hexmask.long.byte 0x4c 24.--27. 1. "  [4|5] , "
hexmask.long.byte 0x50 0.--3. 1. "  [5|5] , "
hexmask.long.byte 0x50 8.--11. 1. "  [6|5] , "
hexmask.long.byte 0x50 16.--19. 1. "  [7|5] , "
hexmask.long.byte 0x50 24.--27. 1. "  [8|5] , "
hexmask.long.byte 0x54 0.--3. 1. "  [9|5] , "
hexmask.long.byte 0x54 8.--11. 1. "  [10|5] , "
hexmask.long.byte 0x54 16.--19. 1. "  [11|5] , "
hexmask.long.byte 0x54 24.--27. 1. "  [12|5] , "
hexmask.long.byte 0x58 0.--3. 1. "  [13|5] , "
hexmask.long.byte 0x58 8.--11. 1. "  [14|5] , "
line.quad 0x5a "0xfe5a"
hexmask.long.byte 0x58 16.--19. 1. " AEXP Weight[0|6]          , "
hexmask.long.byte 0x58 24.--27. 1. "  [1|6] , "
hexmask.long.byte 0x5c 0.--3. 1. "  [2|6] , "
hexmask.long.byte 0x5c 8.--11. 1. "  [3|6] , "
hexmask.long.byte 0x5c 16.--19. 1. "  [4|6] , "
hexmask.long.byte 0x5c 24.--27. 1. "  [5|6] , "
hexmask.long.byte 0x60 0.--3. 1. "  [6|6] , "
hexmask.long.byte 0x60 8.--11. 1. "  [7|6] , "
hexmask.long.byte 0x60 16.--19. 1. "  [8|6] , "
hexmask.long.byte 0x60 24.--27. 1. "  [9|6] , "
hexmask.long.byte 0x64 0.--3. 1. "  [10|6] , "
hexmask.long.byte 0x64 8.--11. 1. "  [11|6] , "
hexmask.long.byte 0x64 16.--19. 1. "  [12|6] , "
hexmask.long.byte 0x64 24.--27. 1. "  [13|6] , "
hexmask.long.byte 0x68 0.--3. 1. "  [14|6] , "
line.quad 0x69 "0xfe69"
hexmask.long.byte 0x68 8.--11. 1. " AEXP Weight[0|7]          , "
hexmask.long.byte 0x68 16.--19. 1. "  [1|7] , "
hexmask.long.byte 0x68 24.--27. 1. "  [2|7] , "
hexmask.long.byte 0x6c 0.--3. 1. "  [3|7] , "
hexmask.long.byte 0x6c 8.--11. 1. "  [4|7] , "
hexmask.long.byte 0x6c 16.--19. 1. "  [5|7] , "
hexmask.long.byte 0x6c 24.--27. 1. "  [6|7] , "
hexmask.long.byte 0x70 0.--3. 1. "  [7|7] , "
hexmask.long.byte 0x70 8.--11. 1. "  [8|7] , "
hexmask.long.byte 0x70 16.--19. 1. "  [9|7] , "
hexmask.long.byte 0x70 24.--27. 1. "  [10|7] , "
hexmask.long.byte 0x74 0.--3. 1. "  [11|7] , "
hexmask.long.byte 0x74 8.--11. 1. "  [12|7] , "
hexmask.long.byte 0x74 16.--19. 1. "  [13|7] , "
hexmask.long.byte 0x74 24.--27. 1. "  [14|7] , "
line.quad 0x78 "0xfe78"
hexmask.long.byte 0x78 0.--3. 1. " AEXP Weight[0|8]          , "
hexmask.long.byte 0x78 8.--11. 1. "  [1|8] , "
hexmask.long.byte 0x78 16.--19. 1. "  [2|8] , "
hexmask.long.byte 0x78 24.--27. 1. "  [3|8] , "
hexmask.long.byte 0x7c 0.--3. 1. "  [4|8] , "
hexmask.long.byte 0x7c 8.--11. 1. "  [5|8] , "
hexmask.long.byte 0x7c 16.--19. 1. "  [6|8] , "
hexmask.long.byte 0x7c 24.--27. 1. "  [7|8] , "
hexmask.long.byte 0x80 0.--3. 1. "  [8|8] , "
hexmask.long.byte 0x80 8.--11. 1. "  [9|8] , "
hexmask.long.byte 0x80 16.--19. 1. "  [10|8] , "
hexmask.long.byte 0x80 24.--27. 1. "  [11|8] , "
hexmask.long.byte 0x84 0.--3. 1. "  [12|8] , "
hexmask.long.byte 0x84 8.--11. 1. "  [13|8] , "
hexmask.long.byte 0x84 16.--19. 1. "  [14|8] , "
line.quad 0x87 "0xfe87"
hexmask.long.byte 0x84 24.--27. 1. " AEXP Weight[0|9]          , "
hexmask.long.byte 0x88 0.--3. 1. "  [1|9] , "
hexmask.long.byte 0x88 8.--11. 1. "  [2|9] , "
hexmask.long.byte 0x88 16.--19. 1. "  [3|9] , "
hexmask.long.byte 0x88 24.--27. 1. "  [4|9] , "
hexmask.long.byte 0x8c 0.--3. 1. "  [5|9] , "
hexmask.long.byte 0x8c 8.--11. 1. "  [6|9] , "
hexmask.long.byte 0x8c 16.--19. 1. "  [7|9] , "
hexmask.long.byte 0x8c 24.--27. 1. "  [8|9] , "
hexmask.long.byte 0x90 0.--3. 1. "  [9|9] , "
hexmask.long.byte 0x90 8.--11. 1. "  [10|9] , "
hexmask.long.byte 0x90 16.--19. 1. "  [11|9] , "
hexmask.long.byte 0x90 24.--27. 1. "  [12|9] , "
hexmask.long.byte 0x94 0.--3. 1. "  [13|9] , "
hexmask.long.byte 0x94 8.--11. 1. "  [14|9] , "
line.quad 0x96 "0xfe96"
hexmask.long.byte 0x94 16.--19. 1. " AEXP Weight[0|10]         , "
hexmask.long.byte 0x94 24.--27. 1. "  [1|10] , "
hexmask.long.byte 0x98 0.--3. 1. "  [2|10] , "
hexmask.long.byte 0x98 8.--11. 1. "  [3|10] , "
hexmask.long.byte 0x98 16.--19. 1. "  [4|10] , "
hexmask.long.byte 0x98 24.--27. 1. "  [5|10] , "
hexmask.long.byte 0x9c 0.--3. 1. "  [6|10] , "
hexmask.long.byte 0x9c 8.--11. 1. "  [7|10] , "
hexmask.long.byte 0x9c 16.--19. 1. "  [8|10] , "
hexmask.long.byte 0x9c 24.--27. 1. "  [9|10] , "
hexmask.long.byte 0xa0 0.--3. 1. "  [10|10] , "
hexmask.long.byte 0xa0 8.--11. 1. "  [11|10] , "
hexmask.long.byte 0xa0 16.--19. 1. "  [12|10] , "
hexmask.long.byte 0xa0 24.--27. 1. "  [13|10] , "
hexmask.long.byte 0xa4 0.--3. 1. "  [14|10] , "
line.quad 0xa5 "0xfea5"
hexmask.long.byte 0xa4 8.--11. 1. " AEXP Weight[0|11]         , "
hexmask.long.byte 0xa4 16.--19. 1. "  [1|11] , "
hexmask.long.byte 0xa4 24.--27. 1. "  [2|11] , "
hexmask.long.byte 0xa8 0.--3. 1. "  [3|11] , "
hexmask.long.byte 0xa8 8.--11. 1. "  [4|11] , "
hexmask.long.byte 0xa8 16.--19. 1. "  [5|11] , "
hexmask.long.byte 0xa8 24.--27. 1. "  [6|11] , "
hexmask.long.byte 0xac 0.--3. 1. "  [7|11] , "
hexmask.long.byte 0xac 8.--11. 1. "  [8|11] , "
hexmask.long.byte 0xac 16.--19. 1. "  [9|11] , "
hexmask.long.byte 0xac 24.--27. 1. "  [10|11] , "
hexmask.long.byte 0xb0 0.--3. 1. "  [11|11] , "
hexmask.long.byte 0xb0 8.--11. 1. "  [12|11] , "
hexmask.long.byte 0xb0 16.--19. 1. "  [13|11] , "
hexmask.long.byte 0xb0 24.--27. 1. "  [14|11] , "
line.quad 0xb4 "0xfeb4"
hexmask.long.byte 0xb4 0.--3. 1. " AEXP Weight[0|12]         , "
hexmask.long.byte 0xb4 8.--11. 1. "  [1|12] , "
hexmask.long.byte 0xb4 16.--19. 1. "  [2|12] , "
hexmask.long.byte 0xb4 24.--27. 1. "  [3|12] , "
hexmask.long.byte 0xb8 0.--3. 1. "  [4|12] , "
hexmask.long.byte 0xb8 8.--11. 1. "  [5|12] , "
hexmask.long.byte 0xb8 16.--19. 1. "  [6|12] , "
hexmask.long.byte 0xb8 24.--27. 1. "  [7|12] , "
hexmask.long.byte 0xbc 0.--3. 1. "  [8|12] , "
hexmask.long.byte 0xbc 8.--11. 1. "  [9|12] , "
hexmask.long.byte 0xbc 16.--19. 1. "  [10|12] , "
hexmask.long.byte 0xbc 24.--27. 1. "  [11|12] , "
hexmask.long.byte 0xc0 0.--3. 1. "  [12|12] , "
hexmask.long.byte 0xc0 8.--11. 1. "  [13|12] , "
hexmask.long.byte 0xc0 16.--19. 1. "  [14|12] , "
line.quad 0xc3 "0xfec3"
hexmask.long.byte 0xc0 24.--27. 1. " AEXP Weight[0|13]         , "
hexmask.long.byte 0xc4 0.--3. 1. "  [1|13] , "
hexmask.long.byte 0xc4 8.--11. 1. "  [2|13] , "
hexmask.long.byte 0xc4 16.--19. 1. "  [3|13] , "
hexmask.long.byte 0xc4 24.--27. 1. "  [4|13] , "
hexmask.long.byte 0xc8 0.--3. 1. "  [5|13] , "
hexmask.long.byte 0xc8 8.--11. 1. "  [6|13] , "
hexmask.long.byte 0xc8 16.--19. 1. "  [7|13] , "
hexmask.long.byte 0xc8 24.--27. 1. "  [8|13] , "
hexmask.long.byte 0xcc 0.--3. 1. "  [9|13] , "
hexmask.long.byte 0xcc 8.--11. 1. "  [10|13] , "
hexmask.long.byte 0xcc 16.--19. 1. "  [11|13] , "
hexmask.long.byte 0xcc 24.--27. 1. "  [12|13] , "
hexmask.long.byte 0xd0 0.--3. 1. "  [13|13] , "
hexmask.long.byte 0xd0 8.--11. 1. "  [14|13] , "
line.quad 0xd2 "0xfed2"
hexmask.long.byte 0xd0 16.--19. 1. " AEXP Weight[0|14]         , "
hexmask.long.byte 0xd0 24.--27. 1. "  [1|14] , "
hexmask.long.byte 0xd4 0.--3. 1. "  [2|14] , "
hexmask.long.byte 0xd4 8.--11. 1. "  [3|14] , "
hexmask.long.byte 0xd4 16.--19. 1. "  [4|14] , "
hexmask.long.byte 0xd4 24.--27. 1. "  [5|14] , "
hexmask.long.byte 0xd8 0.--3. 1. "  [6|14] , "
hexmask.long.byte 0xd8 8.--11. 1. "  [7|14] , "
hexmask.long.byte 0xd8 16.--19. 1. "  [8|14] , "
hexmask.long.byte 0xd8 24.--27. 1. "  [9|14] , "
hexmask.long.byte 0xdc 0.--3. 1. "  [10|14] , "
hexmask.long.byte 0xdc 8.--11. 1. "  [11|14] , "
hexmask.long.byte 0xdc 16.--19. 1. "  [12|14] , "
hexmask.long.byte 0xdc 24.--27. 1. "  [13|14] , "
hexmask.long.byte 0xe0 0.--3. 1. "  [14|14] , "
group.long 0xff00++0xe5
line.quad 0x00 "0xff00"
hexmask.long.byte 0x0 0.--3. 1. " AWB Weight[0|0]           , "
hexmask.long.byte 0x0 8.--11. 1. "  [1|0] , "
hexmask.long.byte 0x0 16.--19. 1. "  [2|0] , "
hexmask.long.byte 0x0 24.--27. 1. "  [3|0] , "
hexmask.long.byte 0x4 0.--3. 1. "  [4|0] , "
hexmask.long.byte 0x4 8.--11. 1. "  [5|0] , "
hexmask.long.byte 0x4 16.--19. 1. "  [6|0] , "
hexmask.long.byte 0x4 24.--27. 1. "  [7|0] , "
hexmask.long.byte 0x8 0.--3. 1. "  [8|0] , "
hexmask.long.byte 0x8 8.--11. 1. "  [9|0] , "
hexmask.long.byte 0x8 16.--19. 1. "  [10|0] , "
hexmask.long.byte 0x8 24.--27. 1. "  [11|0] , "
hexmask.long.byte 0xc 0.--3. 1. "  [12|0] , "
hexmask.long.byte 0xc 8.--11. 1. "  [13|0] , "
hexmask.long.byte 0xc 16.--19. 1. "  [14|0] , "
line.quad 0x0f "0xff0f"
hexmask.long.byte 0xc 24.--27. 1. " AWB Weight[0|1]           , "
hexmask.long.byte 0x10 0.--3. 1. "  [1|1] , "
hexmask.long.byte 0x10 8.--11. 1. "  [2|1] , "
hexmask.long.byte 0x10 16.--19. 1. "  [3|1] , "
hexmask.long.byte 0x10 24.--27. 1. "  [4|1] , "
hexmask.long.byte 0x14 0.--3. 1. "  [5|1] , "
hexmask.long.byte 0x14 8.--11. 1. "  [6|1] , "
hexmask.long.byte 0x14 16.--19. 1. "  [7|1] , "
hexmask.long.byte 0x14 24.--27. 1. "  [8|1] , "
hexmask.long.byte 0x18 0.--3. 1. "  [9|1] , "
hexmask.long.byte 0x18 8.--11. 1. "  [10|1] , "
hexmask.long.byte 0x18 16.--19. 1. "  [11|1] , "
hexmask.long.byte 0x18 24.--27. 1. "  [12|1] , "
hexmask.long.byte 0x1c 0.--3. 1. "  [13|1] , "
hexmask.long.byte 0x1c 8.--11. 1. "  [14|1] , "
line.quad 0x1e "0xff1e"
hexmask.long.byte 0x1c 16.--19. 1. " AWB Weight[0|2]           , "
hexmask.long.byte 0x1c 24.--27. 1. "  [1|2] , "
hexmask.long.byte 0x20 0.--3. 1. "  [2|2] , "
hexmask.long.byte 0x20 8.--11. 1. "  [3|2] , "
hexmask.long.byte 0x20 16.--19. 1. "  [4|2] , "
hexmask.long.byte 0x20 24.--27. 1. "  [5|2] , "
hexmask.long.byte 0x24 0.--3. 1. "  [6|2] , "
hexmask.long.byte 0x24 8.--11. 1. "  [7|2] , "
hexmask.long.byte 0x24 16.--19. 1. "  [8|2] , "
hexmask.long.byte 0x24 24.--27. 1. "  [9|2] , "
hexmask.long.byte 0x28 0.--3. 1. "  [10|2] , "
hexmask.long.byte 0x28 8.--11. 1. "  [11|2] , "
hexmask.long.byte 0x28 16.--19. 1. "  [12|2] , "
hexmask.long.byte 0x28 24.--27. 1. "  [13|2] , "
hexmask.long.byte 0x2c 0.--3. 1. "  [14|2] , "
line.quad 0x2d "0xff2d"
hexmask.long.byte 0x2c 8.--11. 1. " AWB Weight[0|3]           , "
hexmask.long.byte 0x2c 16.--19. 1. "  [1|3] , "
hexmask.long.byte 0x2c 24.--27. 1. "  [2|3] , "
hexmask.long.byte 0x30 0.--3. 1. "  [3|3] , "
hexmask.long.byte 0x30 8.--11. 1. "  [4|3] , "
hexmask.long.byte 0x30 16.--19. 1. "  [5|3] , "
hexmask.long.byte 0x30 24.--27. 1. "  [6|3] , "
hexmask.long.byte 0x34 0.--3. 1. "  [7|3] , "
hexmask.long.byte 0x34 8.--11. 1. "  [8|3] , "
hexmask.long.byte 0x34 16.--19. 1. "  [9|3] , "
hexmask.long.byte 0x34 24.--27. 1. "  [10|3] , "
hexmask.long.byte 0x38 0.--3. 1. "  [11|3] , "
hexmask.long.byte 0x38 8.--11. 1. "  [12|3] , "
hexmask.long.byte 0x38 16.--19. 1. "  [13|3] , "
hexmask.long.byte 0x38 24.--27. 1. "  [14|3] , "
line.quad 0x3c "0xff3c"
hexmask.long.byte 0x3c 0.--3. 1. " AWB Weight[0|4]           , "
hexmask.long.byte 0x3c 8.--11. 1. "  [1|4] , "
hexmask.long.byte 0x3c 16.--19. 1. "  [2|4] , "
hexmask.long.byte 0x3c 24.--27. 1. "  [3|4] , "
hexmask.long.byte 0x40 0.--3. 1. "  [4|4] , "
hexmask.long.byte 0x40 8.--11. 1. "  [5|4] , "
hexmask.long.byte 0x40 16.--19. 1. "  [6|4] , "
hexmask.long.byte 0x40 24.--27. 1. "  [7|4] , "
hexmask.long.byte 0x44 0.--3. 1. "  [8|4] , "
hexmask.long.byte 0x44 8.--11. 1. "  [9|4] , "
hexmask.long.byte 0x44 16.--19. 1. "  [10|4] , "
hexmask.long.byte 0x44 24.--27. 1. "  [11|4] , "
hexmask.long.byte 0x48 0.--3. 1. "  [12|4] , "
hexmask.long.byte 0x48 8.--11. 1. "  [13|4] , "
hexmask.long.byte 0x48 16.--19. 1. "  [14|4] , "
line.quad 0x4b "0xff4b"
hexmask.long.byte 0x48 24.--27. 1. " AWB Weight[0|5]           , "
hexmask.long.byte 0x4c 0.--3. 1. "  [1|5] , "
hexmask.long.byte 0x4c 8.--11. 1. "  [2|5] , "
hexmask.long.byte 0x4c 16.--19. 1. "  [3|5] , "
hexmask.long.byte 0x4c 24.--27. 1. "  [4|5] , "
hexmask.long.byte 0x50 0.--3. 1. "  [5|5] , "
hexmask.long.byte 0x50 8.--11. 1. "  [6|5] , "
hexmask.long.byte 0x50 16.--19. 1. "  [7|5] , "
hexmask.long.byte 0x50 24.--27. 1. "  [8|5] , "
hexmask.long.byte 0x54 0.--3. 1. "  [9|5] , "
hexmask.long.byte 0x54 8.--11. 1. "  [10|5] , "
hexmask.long.byte 0x54 16.--19. 1. "  [11|5] , "
hexmask.long.byte 0x54 24.--27. 1. "  [12|5] , "
hexmask.long.byte 0x58 0.--3. 1. "  [13|5] , "
hexmask.long.byte 0x58 8.--11. 1. "  [14|5] , "
line.quad 0x5a "0xff5a"
hexmask.long.byte 0x58 16.--19. 1. " AWB Weight[0|6]           , "
hexmask.long.byte 0x58 24.--27. 1. "  [1|6] , "
hexmask.long.byte 0x5c 0.--3. 1. "  [2|6] , "
hexmask.long.byte 0x5c 8.--11. 1. "  [3|6] , "
hexmask.long.byte 0x5c 16.--19. 1. "  [4|6] , "
hexmask.long.byte 0x5c 24.--27. 1. "  [5|6] , "
hexmask.long.byte 0x60 0.--3. 1. "  [6|6] , "
hexmask.long.byte 0x60 8.--11. 1. "  [7|6] , "
hexmask.long.byte 0x60 16.--19. 1. "  [8|6] , "
hexmask.long.byte 0x60 24.--27. 1. "  [9|6] , "
hexmask.long.byte 0x64 0.--3. 1. "  [10|6] , "
hexmask.long.byte 0x64 8.--11. 1. "  [11|6] , "
hexmask.long.byte 0x64 16.--19. 1. "  [12|6] , "
hexmask.long.byte 0x64 24.--27. 1. "  [13|6] , "
hexmask.long.byte 0x68 0.--3. 1. "  [14|6] , "
line.quad 0x69 "0xff69"
hexmask.long.byte 0x68 8.--11. 1. " AWB Weight[0|7]           , "
hexmask.long.byte 0x68 16.--19. 1. "  [1|7] , "
hexmask.long.byte 0x68 24.--27. 1. "  [2|7] , "
hexmask.long.byte 0x6c 0.--3. 1. "  [3|7] , "
hexmask.long.byte 0x6c 8.--11. 1. "  [4|7] , "
hexmask.long.byte 0x6c 16.--19. 1. "  [5|7] , "
hexmask.long.byte 0x6c 24.--27. 1. "  [6|7] , "
hexmask.long.byte 0x70 0.--3. 1. "  [7|7] , "
hexmask.long.byte 0x70 8.--11. 1. "  [8|7] , "
hexmask.long.byte 0x70 16.--19. 1. "  [9|7] , "
hexmask.long.byte 0x70 24.--27. 1. "  [10|7] , "
hexmask.long.byte 0x74 0.--3. 1. "  [11|7] , "
hexmask.long.byte 0x74 8.--11. 1. "  [12|7] , "
hexmask.long.byte 0x74 16.--19. 1. "  [13|7] , "
hexmask.long.byte 0x74 24.--27. 1. "  [14|7] , "
line.quad 0x78 "0xff78"
hexmask.long.byte 0x78 0.--3. 1. " AWB Weight[0|8]           , "
hexmask.long.byte 0x78 8.--11. 1. "  [1|8] , "
hexmask.long.byte 0x78 16.--19. 1. "  [2|8] , "
hexmask.long.byte 0x78 24.--27. 1. "  [3|8] , "
hexmask.long.byte 0x7c 0.--3. 1. "  [4|8] , "
hexmask.long.byte 0x7c 8.--11. 1. "  [5|8] , "
hexmask.long.byte 0x7c 16.--19. 1. "  [6|8] , "
hexmask.long.byte 0x7c 24.--27. 1. "  [7|8] , "
hexmask.long.byte 0x80 0.--3. 1. "  [8|8] , "
hexmask.long.byte 0x80 8.--11. 1. "  [9|8] , "
hexmask.long.byte 0x80 16.--19. 1. "  [10|8] , "
hexmask.long.byte 0x80 24.--27. 1. "  [11|8] , "
hexmask.long.byte 0x84 0.--3. 1. "  [12|8] , "
hexmask.long.byte 0x84 8.--11. 1. "  [13|8] , "
hexmask.long.byte 0x84 16.--19. 1. "  [14|8] , "
line.quad 0x87 "0xff87"
hexmask.long.byte 0x84 24.--27. 1. " AWB Weight[0|9]           , "
hexmask.long.byte 0x88 0.--3. 1. "  [1|9] , "
hexmask.long.byte 0x88 8.--11. 1. "  [2|9] , "
hexmask.long.byte 0x88 16.--19. 1. "  [3|9] , "
hexmask.long.byte 0x88 24.--27. 1. "  [4|9] , "
hexmask.long.byte 0x8c 0.--3. 1. "  [5|9] , "
hexmask.long.byte 0x8c 8.--11. 1. "  [6|9] , "
hexmask.long.byte 0x8c 16.--19. 1. "  [7|9] , "
hexmask.long.byte 0x8c 24.--27. 1. "  [8|9] , "
hexmask.long.byte 0x90 0.--3. 1. "  [9|9] , "
hexmask.long.byte 0x90 8.--11. 1. "  [10|9] , "
hexmask.long.byte 0x90 16.--19. 1. "  [11|9] , "
hexmask.long.byte 0x90 24.--27. 1. "  [12|9] , "
hexmask.long.byte 0x94 0.--3. 1. "  [13|9] , "
hexmask.long.byte 0x94 8.--11. 1. "  [14|9] , "
line.quad 0x96 "0xff96"
hexmask.long.byte 0x94 16.--19. 1. " AWB Weight[0|10]          , "
hexmask.long.byte 0x94 24.--27. 1. "  [1|10] , "
hexmask.long.byte 0x98 0.--3. 1. "  [2|10] , "
hexmask.long.byte 0x98 8.--11. 1. "  [3|10] , "
hexmask.long.byte 0x98 16.--19. 1. "  [4|10] , "
hexmask.long.byte 0x98 24.--27. 1. "  [5|10] , "
hexmask.long.byte 0x9c 0.--3. 1. "  [6|10] , "
hexmask.long.byte 0x9c 8.--11. 1. "  [7|10] , "
hexmask.long.byte 0x9c 16.--19. 1. "  [8|10] , "
hexmask.long.byte 0x9c 24.--27. 1. "  [9|10] , "
hexmask.long.byte 0xa0 0.--3. 1. "  [10|10] , "
hexmask.long.byte 0xa0 8.--11. 1. "  [11|10] , "
hexmask.long.byte 0xa0 16.--19. 1. "  [12|10] , "
hexmask.long.byte 0xa0 24.--27. 1. "  [13|10] , "
hexmask.long.byte 0xa4 0.--3. 1. "  [14|10] , "
line.quad 0xa5 "0xffa5"
hexmask.long.byte 0xa4 8.--11. 1. " AWB Weight[0|11]          , "
hexmask.long.byte 0xa4 16.--19. 1. "  [1|11] , "
hexmask.long.byte 0xa4 24.--27. 1. "  [2|11] , "
hexmask.long.byte 0xa8 0.--3. 1. "  [3|11] , "
hexmask.long.byte 0xa8 8.--11. 1. "  [4|11] , "
hexmask.long.byte 0xa8 16.--19. 1. "  [5|11] , "
hexmask.long.byte 0xa8 24.--27. 1. "  [6|11] , "
hexmask.long.byte 0xac 0.--3. 1. "  [7|11] , "
hexmask.long.byte 0xac 8.--11. 1. "  [8|11] , "
hexmask.long.byte 0xac 16.--19. 1. "  [9|11] , "
hexmask.long.byte 0xac 24.--27. 1. "  [10|11] , "
hexmask.long.byte 0xb0 0.--3. 1. "  [11|11] , "
hexmask.long.byte 0xb0 8.--11. 1. "  [12|11] , "
hexmask.long.byte 0xb0 16.--19. 1. "  [13|11] , "
hexmask.long.byte 0xb0 24.--27. 1. "  [14|11] , "
line.quad 0xb4 "0xffb4"
hexmask.long.byte 0xb4 0.--3. 1. " AWB Weight[0|12]          , "
hexmask.long.byte 0xb4 8.--11. 1. "  [1|12] , "
hexmask.long.byte 0xb4 16.--19. 1. "  [2|12] , "
hexmask.long.byte 0xb4 24.--27. 1. "  [3|12] , "
hexmask.long.byte 0xb8 0.--3. 1. "  [4|12] , "
hexmask.long.byte 0xb8 8.--11. 1. "  [5|12] , "
hexmask.long.byte 0xb8 16.--19. 1. "  [6|12] , "
hexmask.long.byte 0xb8 24.--27. 1. "  [7|12] , "
hexmask.long.byte 0xbc 0.--3. 1. "  [8|12] , "
hexmask.long.byte 0xbc 8.--11. 1. "  [9|12] , "
hexmask.long.byte 0xbc 16.--19. 1. "  [10|12] , "
hexmask.long.byte 0xbc 24.--27. 1. "  [11|12] , "
hexmask.long.byte 0xc0 0.--3. 1. "  [12|12] , "
hexmask.long.byte 0xc0 8.--11. 1. "  [13|12] , "
hexmask.long.byte 0xc0 16.--19. 1. "  [14|12] , "
line.quad 0xc3 "0xffc3"
hexmask.long.byte 0xc0 24.--27. 1. " AWB Weight[0|13]          , "
hexmask.long.byte 0xc4 0.--3. 1. "  [1|13] , "
hexmask.long.byte 0xc4 8.--11. 1. "  [2|13] , "
hexmask.long.byte 0xc4 16.--19. 1. "  [3|13] , "
hexmask.long.byte 0xc4 24.--27. 1. "  [4|13] , "
hexmask.long.byte 0xc8 0.--3. 1. "  [5|13] , "
hexmask.long.byte 0xc8 8.--11. 1. "  [6|13] , "
hexmask.long.byte 0xc8 16.--19. 1. "  [7|13] , "
hexmask.long.byte 0xc8 24.--27. 1. "  [8|13] , "
hexmask.long.byte 0xcc 0.--3. 1. "  [9|13] , "
hexmask.long.byte 0xcc 8.--11. 1. "  [10|13] , "
hexmask.long.byte 0xcc 16.--19. 1. "  [11|13] , "
hexmask.long.byte 0xcc 24.--27. 1. "  [12|13] , "
hexmask.long.byte 0xd0 0.--3. 1. "  [13|13] , "
hexmask.long.byte 0xd0 8.--11. 1. "  [14|13] , "
line.quad 0xd2 "0xffd2"
hexmask.long.byte 0xd0 16.--19. 1. " AWB Weight[0|14]          , "
hexmask.long.byte 0xd0 24.--27. 1. "  [1|14] , "
hexmask.long.byte 0xd4 0.--3. 1. "  [2|14] , "
hexmask.long.byte 0xd4 8.--11. 1. "  [3|14] , "
hexmask.long.byte 0xd4 16.--19. 1. "  [4|14] , "
hexmask.long.byte 0xd4 24.--27. 1. "  [5|14] , "
hexmask.long.byte 0xd8 0.--3. 1. "  [6|14] , "
hexmask.long.byte 0xd8 8.--11. 1. "  [7|14] , "
hexmask.long.byte 0xd8 16.--19. 1. "  [8|14] , "
hexmask.long.byte 0xd8 24.--27. 1. "  [9|14] , "
hexmask.long.byte 0xdc 0.--3. 1. "  [10|14] , "
hexmask.long.byte 0xdc 8.--11. 1. "  [11|14] , "
hexmask.long.byte 0xdc 16.--19. 1. "  [12|14] , "
hexmask.long.byte 0xdc 24.--27. 1. "  [13|14] , "
hexmask.long.byte 0xe0 0.--3. 1. "  [14|14] , "
TREE.END
TREE "gamma be0 mem"
group.long 0x10000++0x80
line.long 0x00 "0x10000"
hexmask.long.long 0x0 0.--31. 1. " Data[0]                   ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
hexmask.long.long 0x10 0.--31. 1. " [4] , "
hexmask.long.long 0x14 0.--31. 1. " [5] , "
hexmask.long.long 0x18 0.--31. 1. " [6] , "
hexmask.long.long 0x1c 0.--31. 1. " [7] , "
hexmask.long.long 0x20 0.--31. 1. " [8] , "
hexmask.long.long 0x24 0.--31. 1. " [9] , "
hexmask.long.long 0x28 0.--31. 1. " [10], "
hexmask.long.long 0x2c 0.--31. 1. " [11], "
hexmask.long.long 0x30 0.--31. 1. " [12], "
hexmask.long.long 0x34 0.--31. 1. " [13], "
hexmask.long.long 0x38 0.--31. 1. " [14], "
hexmask.long.long 0x3c 0.--31. 1. " [15], "
hexmask.long.long 0x40 0.--31. 1. " [16], "
hexmask.long.long 0x44 0.--31. 1. " [17], "
hexmask.long.long 0x48 0.--31. 1. " [18], "
hexmask.long.long 0x4c 0.--31. 1. " [19], "
hexmask.long.long 0x50 0.--31. 1. " [20], "
hexmask.long.long 0x54 0.--31. 1. " [21], "
hexmask.long.long 0x58 0.--31. 1. " [22], "
hexmask.long.long 0x5c 0.--31. 1. " [23], "
hexmask.long.long 0x60 0.--31. 1. " [24], "
hexmask.long.long 0x64 0.--31. 1. " [25], "
hexmask.long.long 0x68 0.--31. 1. " [26], "
hexmask.long.long 0x6c 0.--31. 1. " [27], "
hexmask.long.long 0x70 0.--31. 1. " [28], "
hexmask.long.long 0x74 0.--31. 1. " [29], "
hexmask.long.long 0x78 0.--31. 1. " [30], "
hexmask.long.long 0x7c 0.--31. 1. " [31], "
TREE.END
TREE "ca filter mem"
group.long 0x10100++0x80
line.long 0x00 "0x10100"
hexmask.long.long 0x0 0.--31. 1. " Data[0]                   ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
hexmask.long.long 0x10 0.--31. 1. " [4] , "
hexmask.long.long 0x14 0.--31. 1. " [5] , "
hexmask.long.long 0x18 0.--31. 1. " [6] , "
hexmask.long.long 0x1c 0.--31. 1. " [7] , "
hexmask.long.long 0x20 0.--31. 1. " [8] , "
hexmask.long.long 0x24 0.--31. 1. " [9] , "
hexmask.long.long 0x28 0.--31. 1. " [10], "
hexmask.long.long 0x2c 0.--31. 1. " [11], "
hexmask.long.long 0x30 0.--31. 1. " [12], "
hexmask.long.long 0x34 0.--31. 1. " [13], "
hexmask.long.long 0x38 0.--31. 1. " [14], "
hexmask.long.long 0x3c 0.--31. 1. " [15], "
hexmask.long.long 0x40 0.--31. 1. " [16], "
hexmask.long.long 0x44 0.--31. 1. " [17], "
hexmask.long.long 0x48 0.--31. 1. " [18], "
hexmask.long.long 0x4c 0.--31. 1. " [19], "
hexmask.long.long 0x50 0.--31. 1. " [20], "
hexmask.long.long 0x54 0.--31. 1. " [21], "
hexmask.long.long 0x58 0.--31. 1. " [22], "
hexmask.long.long 0x5c 0.--31. 1. " [23], "
hexmask.long.long 0x60 0.--31. 1. " [24], "
hexmask.long.long 0x64 0.--31. 1. " [25], "
hexmask.long.long 0x68 0.--31. 1. " [26], "
hexmask.long.long 0x6c 0.--31. 1. " [27], "
hexmask.long.long 0x70 0.--31. 1. " [28], "
hexmask.long.long 0x74 0.--31. 1. " [29], "
hexmask.long.long 0x78 0.--31. 1. " [30], "
hexmask.long.long 0x7c 0.--31. 1. " [31], "
TREE.END
TREE "(out_format_lut_rgb) out format lut"
group.long 0x11000++0x4
line.long 0x0 "0x11000"
button "Data 0x11000" "B::Data.dump (0xFEC11000) /DIALOG"
TREE.END
TREE "(out_format_lut_yuv) out format lut"
group.long 0x11400++0x4
line.long 0x0 "0x11400"
button "Data 0x11400" "B::Data.dump (0xFEC11400) /DIALOG"
TREE.END
TREE "(out_format_lut_luv) out format lut"
group.long 0x11800++0x4
line.long 0x0 "0x11800"
button "Data 0x11800" "B::Data.dump (0xFEC11800) /DIALOG"
TREE.END
TREE "(out_format_lut_ir) out format lut"
group.long 0x11c00++0x4
line.long 0x0 "0x11c00"
button "Data 0x11c00" "B::Data.dump (0xFEC11C00) /DIALOG"
TREE.END
TREE "iridix fwd mem"
group.long 0x12000++0x204
line.long 0x00 "0x12000"
hexmask.long.long 0x0 0.--31. 1. " Data[0]                   ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
hexmask.long.long 0x10 0.--31. 1. " [4] , "
hexmask.long.long 0x14 0.--31. 1. " [5] , "
hexmask.long.long 0x18 0.--31. 1. " [6] , "
hexmask.long.long 0x1c 0.--31. 1. " [7] , "
hexmask.long.long 0x20 0.--31. 1. " [8] , "
hexmask.long.long 0x24 0.--31. 1. " [9] , "
hexmask.long.long 0x28 0.--31. 1. " [10], "
hexmask.long.long 0x2c 0.--31. 1. " [11], "
hexmask.long.long 0x30 0.--31. 1. " [12], "
hexmask.long.long 0x34 0.--31. 1. " [13], "
hexmask.long.long 0x38 0.--31. 1. " [14], "
hexmask.long.long 0x3c 0.--31. 1. " [15], "
hexmask.long.long 0x40 0.--31. 1. " [16], "
hexmask.long.long 0x44 0.--31. 1. " [17], "
hexmask.long.long 0x48 0.--31. 1. " [18], "
hexmask.long.long 0x4c 0.--31. 1. " [19], "
hexmask.long.long 0x50 0.--31. 1. " [20], "
hexmask.long.long 0x54 0.--31. 1. " [21], "
hexmask.long.long 0x58 0.--31. 1. " [22], "
hexmask.long.long 0x5c 0.--31. 1. " [23], "
hexmask.long.long 0x60 0.--31. 1. " [24], "
hexmask.long.long 0x64 0.--31. 1. " [25], "
hexmask.long.long 0x68 0.--31. 1. " [26], "
hexmask.long.long 0x6c 0.--31. 1. " [27], "
hexmask.long.long 0x70 0.--31. 1. " [28], "
hexmask.long.long 0x74 0.--31. 1. " [29], "
hexmask.long.long 0x78 0.--31. 1. " [30], "
hexmask.long.long 0x7c 0.--31. 1. " [31], "
hexmask.long.long 0x80 0.--31. 1. " [32], "
hexmask.long.long 0x84 0.--31. 1. " [33], "
hexmask.long.long 0x88 0.--31. 1. " [34], "
hexmask.long.long 0x8c 0.--31. 1. " [35], "
hexmask.long.long 0x90 0.--31. 1. " [36], "
hexmask.long.long 0x94 0.--31. 1. " [37], "
hexmask.long.long 0x98 0.--31. 1. " [38], "
hexmask.long.long 0x9c 0.--31. 1. " [39], "
hexmask.long.long 0xa0 0.--31. 1. " [40], "
hexmask.long.long 0xa4 0.--31. 1. " [41], "
hexmask.long.long 0xa8 0.--31. 1. " [42], "
hexmask.long.long 0xac 0.--31. 1. " [43], "
hexmask.long.long 0xb0 0.--31. 1. " [44], "
hexmask.long.long 0xb4 0.--31. 1. " [45], "
hexmask.long.long 0xb8 0.--31. 1. " [46], "
hexmask.long.long 0xbc 0.--31. 1. " [47], "
hexmask.long.long 0xc0 0.--31. 1. " [48], "
hexmask.long.long 0xc4 0.--31. 1. " [49], "
hexmask.long.long 0xc8 0.--31. 1. " [50], "
hexmask.long.long 0xcc 0.--31. 1. " [51], "
hexmask.long.long 0xd0 0.--31. 1. " [52], "
hexmask.long.long 0xd4 0.--31. 1. " [53], "
hexmask.long.long 0xd8 0.--31. 1. " [54], "
hexmask.long.long 0xdc 0.--31. 1. " [55], "
hexmask.long.long 0xe0 0.--31. 1. " [56], "
hexmask.long.long 0xe4 0.--31. 1. " [57], "
hexmask.long.long 0xe8 0.--31. 1. " [58], "
hexmask.long.long 0xec 0.--31. 1. " [59], "
hexmask.long.long 0xf0 0.--31. 1. " [60], "
hexmask.long.long 0xf4 0.--31. 1. " [61], "
hexmask.long.long 0xf8 0.--31. 1. " [62], "
hexmask.long.long 0xfc 0.--31. 1. " [63], "
hexmask.long.long 0x100 0.--31. 1. " [64], "
hexmask.long.long 0x104 0.--31. 1. " [65], "
hexmask.long.long 0x108 0.--31. 1. " [66], "
hexmask.long.long 0x10c 0.--31. 1. " [67], "
hexmask.long.long 0x110 0.--31. 1. " [68], "
hexmask.long.long 0x114 0.--31. 1. " [69], "
hexmask.long.long 0x118 0.--31. 1. " [70], "
hexmask.long.long 0x11c 0.--31. 1. " [71], "
hexmask.long.long 0x120 0.--31. 1. " [72], "
hexmask.long.long 0x124 0.--31. 1. " [73], "
hexmask.long.long 0x128 0.--31. 1. " [74], "
hexmask.long.long 0x12c 0.--31. 1. " [75], "
hexmask.long.long 0x130 0.--31. 1. " [76], "
hexmask.long.long 0x134 0.--31. 1. " [77], "
hexmask.long.long 0x138 0.--31. 1. " [78], "
hexmask.long.long 0x13c 0.--31. 1. " [79], "
hexmask.long.long 0x140 0.--31. 1. " [80], "
hexmask.long.long 0x144 0.--31. 1. " [81], "
hexmask.long.long 0x148 0.--31. 1. " [82], "
hexmask.long.long 0x14c 0.--31. 1. " [83], "
hexmask.long.long 0x150 0.--31. 1. " [84], "
hexmask.long.long 0x154 0.--31. 1. " [85], "
hexmask.long.long 0x158 0.--31. 1. " [86], "
hexmask.long.long 0x15c 0.--31. 1. " [87], "
hexmask.long.long 0x160 0.--31. 1. " [88], "
hexmask.long.long 0x164 0.--31. 1. " [89], "
hexmask.long.long 0x168 0.--31. 1. " [90], "
hexmask.long.long 0x16c 0.--31. 1. " [91], "
hexmask.long.long 0x170 0.--31. 1. " [92], "
hexmask.long.long 0x174 0.--31. 1. " [93], "
hexmask.long.long 0x178 0.--31. 1. " [94], "
hexmask.long.long 0x17c 0.--31. 1. " [95], "
hexmask.long.long 0x180 0.--31. 1. " [96], "
hexmask.long.long 0x184 0.--31. 1. " [97], "
hexmask.long.long 0x188 0.--31. 1. " [98], "
hexmask.long.long 0x18c 0.--31. 1. " [99], "
hexmask.long.long 0x190 0.--31. 1. " [100], "
hexmask.long.long 0x194 0.--31. 1. " [101], "
hexmask.long.long 0x198 0.--31. 1. " [102], "
hexmask.long.long 0x19c 0.--31. 1. " [103], "
hexmask.long.long 0x1a0 0.--31. 1. " [104], "
hexmask.long.long 0x1a4 0.--31. 1. " [105], "
hexmask.long.long 0x1a8 0.--31. 1. " [106], "
hexmask.long.long 0x1ac 0.--31. 1. " [107], "
hexmask.long.long 0x1b0 0.--31. 1. " [108], "
hexmask.long.long 0x1b4 0.--31. 1. " [109], "
hexmask.long.long 0x1b8 0.--31. 1. " [110], "
hexmask.long.long 0x1bc 0.--31. 1. " [111], "
hexmask.long.long 0x1c0 0.--31. 1. " [112], "
hexmask.long.long 0x1c4 0.--31. 1. " [113], "
hexmask.long.long 0x1c8 0.--31. 1. " [114], "
hexmask.long.long 0x1cc 0.--31. 1. " [115], "
hexmask.long.long 0x1d0 0.--31. 1. " [116], "
hexmask.long.long 0x1d4 0.--31. 1. " [117], "
hexmask.long.long 0x1d8 0.--31. 1. " [118], "
hexmask.long.long 0x1dc 0.--31. 1. " [119], "
hexmask.long.long 0x1e0 0.--31. 1. " [120], "
hexmask.long.long 0x1e4 0.--31. 1. " [121], "
hexmask.long.long 0x1e8 0.--31. 1. " [122], "
hexmask.long.long 0x1ec 0.--31. 1. " [123], "
hexmask.long.long 0x1f0 0.--31. 1. " [124], "
hexmask.long.long 0x1f4 0.--31. 1. " [125], "
hexmask.long.long 0x1f8 0.--31. 1. " [126], "
hexmask.long.long 0x1fc 0.--31. 1. " [127], "
hexmask.long.long 0x200 0.--31. 1. " [128], "
TREE.END
TREE "iridix rev mem"
group.long 0x12400++0x204
line.long 0x00 "0x12400"
hexmask.long.long 0x0 0.--31. 1. " Data[0]                   ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
hexmask.long.long 0x10 0.--31. 1. " [4] , "
hexmask.long.long 0x14 0.--31. 1. " [5] , "
hexmask.long.long 0x18 0.--31. 1. " [6] , "
hexmask.long.long 0x1c 0.--31. 1. " [7] , "
hexmask.long.long 0x20 0.--31. 1. " [8] , "
hexmask.long.long 0x24 0.--31. 1. " [9] , "
hexmask.long.long 0x28 0.--31. 1. " [10], "
hexmask.long.long 0x2c 0.--31. 1. " [11], "
hexmask.long.long 0x30 0.--31. 1. " [12], "
hexmask.long.long 0x34 0.--31. 1. " [13], "
hexmask.long.long 0x38 0.--31. 1. " [14], "
hexmask.long.long 0x3c 0.--31. 1. " [15], "
hexmask.long.long 0x40 0.--31. 1. " [16], "
hexmask.long.long 0x44 0.--31. 1. " [17], "
hexmask.long.long 0x48 0.--31. 1. " [18], "
hexmask.long.long 0x4c 0.--31. 1. " [19], "
hexmask.long.long 0x50 0.--31. 1. " [20], "
hexmask.long.long 0x54 0.--31. 1. " [21], "
hexmask.long.long 0x58 0.--31. 1. " [22], "
hexmask.long.long 0x5c 0.--31. 1. " [23], "
hexmask.long.long 0x60 0.--31. 1. " [24], "
hexmask.long.long 0x64 0.--31. 1. " [25], "
hexmask.long.long 0x68 0.--31. 1. " [26], "
hexmask.long.long 0x6c 0.--31. 1. " [27], "
hexmask.long.long 0x70 0.--31. 1. " [28], "
hexmask.long.long 0x74 0.--31. 1. " [29], "
hexmask.long.long 0x78 0.--31. 1. " [30], "
hexmask.long.long 0x7c 0.--31. 1. " [31], "
hexmask.long.long 0x80 0.--31. 1. " [32], "
hexmask.long.long 0x84 0.--31. 1. " [33], "
hexmask.long.long 0x88 0.--31. 1. " [34], "
hexmask.long.long 0x8c 0.--31. 1. " [35], "
hexmask.long.long 0x90 0.--31. 1. " [36], "
hexmask.long.long 0x94 0.--31. 1. " [37], "
hexmask.long.long 0x98 0.--31. 1. " [38], "
hexmask.long.long 0x9c 0.--31. 1. " [39], "
hexmask.long.long 0xa0 0.--31. 1. " [40], "
hexmask.long.long 0xa4 0.--31. 1. " [41], "
hexmask.long.long 0xa8 0.--31. 1. " [42], "
hexmask.long.long 0xac 0.--31. 1. " [43], "
hexmask.long.long 0xb0 0.--31. 1. " [44], "
hexmask.long.long 0xb4 0.--31. 1. " [45], "
hexmask.long.long 0xb8 0.--31. 1. " [46], "
hexmask.long.long 0xbc 0.--31. 1. " [47], "
hexmask.long.long 0xc0 0.--31. 1. " [48], "
hexmask.long.long 0xc4 0.--31. 1. " [49], "
hexmask.long.long 0xc8 0.--31. 1. " [50], "
hexmask.long.long 0xcc 0.--31. 1. " [51], "
hexmask.long.long 0xd0 0.--31. 1. " [52], "
hexmask.long.long 0xd4 0.--31. 1. " [53], "
hexmask.long.long 0xd8 0.--31. 1. " [54], "
hexmask.long.long 0xdc 0.--31. 1. " [55], "
hexmask.long.long 0xe0 0.--31. 1. " [56], "
hexmask.long.long 0xe4 0.--31. 1. " [57], "
hexmask.long.long 0xe8 0.--31. 1. " [58], "
hexmask.long.long 0xec 0.--31. 1. " [59], "
hexmask.long.long 0xf0 0.--31. 1. " [60], "
hexmask.long.long 0xf4 0.--31. 1. " [61], "
hexmask.long.long 0xf8 0.--31. 1. " [62], "
hexmask.long.long 0xfc 0.--31. 1. " [63], "
hexmask.long.long 0x100 0.--31. 1. " [64], "
hexmask.long.long 0x104 0.--31. 1. " [65], "
hexmask.long.long 0x108 0.--31. 1. " [66], "
hexmask.long.long 0x10c 0.--31. 1. " [67], "
hexmask.long.long 0x110 0.--31. 1. " [68], "
hexmask.long.long 0x114 0.--31. 1. " [69], "
hexmask.long.long 0x118 0.--31. 1. " [70], "
hexmask.long.long 0x11c 0.--31. 1. " [71], "
hexmask.long.long 0x120 0.--31. 1. " [72], "
hexmask.long.long 0x124 0.--31. 1. " [73], "
hexmask.long.long 0x128 0.--31. 1. " [74], "
hexmask.long.long 0x12c 0.--31. 1. " [75], "
hexmask.long.long 0x130 0.--31. 1. " [76], "
hexmask.long.long 0x134 0.--31. 1. " [77], "
hexmask.long.long 0x138 0.--31. 1. " [78], "
hexmask.long.long 0x13c 0.--31. 1. " [79], "
hexmask.long.long 0x140 0.--31. 1. " [80], "
hexmask.long.long 0x144 0.--31. 1. " [81], "
hexmask.long.long 0x148 0.--31. 1. " [82], "
hexmask.long.long 0x14c 0.--31. 1. " [83], "
hexmask.long.long 0x150 0.--31. 1. " [84], "
hexmask.long.long 0x154 0.--31. 1. " [85], "
hexmask.long.long 0x158 0.--31. 1. " [86], "
hexmask.long.long 0x15c 0.--31. 1. " [87], "
hexmask.long.long 0x160 0.--31. 1. " [88], "
hexmask.long.long 0x164 0.--31. 1. " [89], "
hexmask.long.long 0x168 0.--31. 1. " [90], "
hexmask.long.long 0x16c 0.--31. 1. " [91], "
hexmask.long.long 0x170 0.--31. 1. " [92], "
hexmask.long.long 0x174 0.--31. 1. " [93], "
hexmask.long.long 0x178 0.--31. 1. " [94], "
hexmask.long.long 0x17c 0.--31. 1. " [95], "
hexmask.long.long 0x180 0.--31. 1. " [96], "
hexmask.long.long 0x184 0.--31. 1. " [97], "
hexmask.long.long 0x188 0.--31. 1. " [98], "
hexmask.long.long 0x18c 0.--31. 1. " [99], "
hexmask.long.long 0x190 0.--31. 1. " [100], "
hexmask.long.long 0x194 0.--31. 1. " [101], "
hexmask.long.long 0x198 0.--31. 1. " [102], "
hexmask.long.long 0x19c 0.--31. 1. " [103], "
hexmask.long.long 0x1a0 0.--31. 1. " [104], "
hexmask.long.long 0x1a4 0.--31. 1. " [105], "
hexmask.long.long 0x1a8 0.--31. 1. " [106], "
hexmask.long.long 0x1ac 0.--31. 1. " [107], "
hexmask.long.long 0x1b0 0.--31. 1. " [108], "
hexmask.long.long 0x1b4 0.--31. 1. " [109], "
hexmask.long.long 0x1b8 0.--31. 1. " [110], "
hexmask.long.long 0x1bc 0.--31. 1. " [111], "
hexmask.long.long 0x1c0 0.--31. 1. " [112], "
hexmask.long.long 0x1c4 0.--31. 1. " [113], "
hexmask.long.long 0x1c8 0.--31. 1. " [114], "
hexmask.long.long 0x1cc 0.--31. 1. " [115], "
hexmask.long.long 0x1d0 0.--31. 1. " [116], "
hexmask.long.long 0x1d4 0.--31. 1. " [117], "
hexmask.long.long 0x1d8 0.--31. 1. " [118], "
hexmask.long.long 0x1dc 0.--31. 1. " [119], "
hexmask.long.long 0x1e0 0.--31. 1. " [120], "
hexmask.long.long 0x1e4 0.--31. 1. " [121], "
hexmask.long.long 0x1e8 0.--31. 1. " [122], "
hexmask.long.long 0x1ec 0.--31. 1. " [123], "
hexmask.long.long 0x1f0 0.--31. 1. " [124], "
hexmask.long.long 0x1f4 0.--31. 1. " [125], "
hexmask.long.long 0x1f8 0.--31. 1. " [126], "
hexmask.long.long 0x1fc 0.--31. 1. " [127], "
hexmask.long.long 0x200 0.--31. 1. " [128], "
TREE.END
TREE "radial shading mem"
group.long 0x12800++0x384
line.long 0x00 "0x12800"
hexmask.long.long 0x0 0.--31. 1. " Data[0]                   ,  "
hexmask.long.long 0x4 0.--31. 1. " [1] , "
hexmask.long.long 0x8 0.--31. 1. " [2] , "
hexmask.long.long 0xc 0.--31. 1. " [3] , "
hexmask.long.long 0x10 0.--31. 1. " [4] , "
hexmask.long.long 0x14 0.--31. 1. " [5] , "
hexmask.long.long 0x18 0.--31. 1. " [6] , "
hexmask.long.long 0x1c 0.--31. 1. " [7] , "
hexmask.long.long 0x20 0.--31. 1. " [8] , "
hexmask.long.long 0x24 0.--31. 1. " [9] , "
hexmask.long.long 0x28 0.--31. 1. " [10], "
hexmask.long.long 0x2c 0.--31. 1. " [11], "
hexmask.long.long 0x30 0.--31. 1. " [12], "
hexmask.long.long 0x34 0.--31. 1. " [13], "
hexmask.long.long 0x38 0.--31. 1. " [14], "
hexmask.long.long 0x3c 0.--31. 1. " [15], "
hexmask.long.long 0x40 0.--31. 1. " [16], "
hexmask.long.long 0x44 0.--31. 1. " [17], "
hexmask.long.long 0x48 0.--31. 1. " [18], "
hexmask.long.long 0x4c 0.--31. 1. " [19], "
hexmask.long.long 0x50 0.--31. 1. " [20], "
hexmask.long.long 0x54 0.--31. 1. " [21], "
hexmask.long.long 0x58 0.--31. 1. " [22], "
hexmask.long.long 0x5c 0.--31. 1. " [23], "
hexmask.long.long 0x60 0.--31. 1. " [24], "
hexmask.long.long 0x64 0.--31. 1. " [25], "
hexmask.long.long 0x68 0.--31. 1. " [26], "
hexmask.long.long 0x6c 0.--31. 1. " [27], "
hexmask.long.long 0x70 0.--31. 1. " [28], "
hexmask.long.long 0x74 0.--31. 1. " [29], "
hexmask.long.long 0x78 0.--31. 1. " [30], "
hexmask.long.long 0x7c 0.--31. 1. " [31], "
hexmask.long.long 0x80 0.--31. 1. " [32], "
hexmask.long.long 0x84 0.--31. 1. " [33], "
hexmask.long.long 0x88 0.--31. 1. " [34], "
hexmask.long.long 0x8c 0.--31. 1. " [35], "
hexmask.long.long 0x90 0.--31. 1. " [36], "
hexmask.long.long 0x94 0.--31. 1. " [37], "
hexmask.long.long 0x98 0.--31. 1. " [38], "
hexmask.long.long 0x9c 0.--31. 1. " [39], "
hexmask.long.long 0xa0 0.--31. 1. " [40], "
hexmask.long.long 0xa4 0.--31. 1. " [41], "
hexmask.long.long 0xa8 0.--31. 1. " [42], "
hexmask.long.long 0xac 0.--31. 1. " [43], "
hexmask.long.long 0xb0 0.--31. 1. " [44], "
hexmask.long.long 0xb4 0.--31. 1. " [45], "
hexmask.long.long 0xb8 0.--31. 1. " [46], "
hexmask.long.long 0xbc 0.--31. 1. " [47], "
hexmask.long.long 0xc0 0.--31. 1. " [48], "
hexmask.long.long 0xc4 0.--31. 1. " [49], "
hexmask.long.long 0xc8 0.--31. 1. " [50], "
hexmask.long.long 0xcc 0.--31. 1. " [51], "
hexmask.long.long 0xd0 0.--31. 1. " [52], "
hexmask.long.long 0xd4 0.--31. 1. " [53], "
hexmask.long.long 0xd8 0.--31. 1. " [54], "
hexmask.long.long 0xdc 0.--31. 1. " [55], "
hexmask.long.long 0xe0 0.--31. 1. " [56], "
hexmask.long.long 0xe4 0.--31. 1. " [57], "
hexmask.long.long 0xe8 0.--31. 1. " [58], "
hexmask.long.long 0xec 0.--31. 1. " [59], "
hexmask.long.long 0xf0 0.--31. 1. " [60], "
hexmask.long.long 0xf4 0.--31. 1. " [61], "
hexmask.long.long 0xf8 0.--31. 1. " [62], "
hexmask.long.long 0xfc 0.--31. 1. " [63], "
hexmask.long.long 0x100 0.--31. 1. " [64], "
hexmask.long.long 0x104 0.--31. 1. " [65], "
hexmask.long.long 0x108 0.--31. 1. " [66], "
hexmask.long.long 0x10c 0.--31. 1. " [67], "
hexmask.long.long 0x110 0.--31. 1. " [68], "
hexmask.long.long 0x114 0.--31. 1. " [69], "
hexmask.long.long 0x118 0.--31. 1. " [70], "
hexmask.long.long 0x11c 0.--31. 1. " [71], "
hexmask.long.long 0x120 0.--31. 1. " [72], "
hexmask.long.long 0x124 0.--31. 1. " [73], "
hexmask.long.long 0x128 0.--31. 1. " [74], "
hexmask.long.long 0x12c 0.--31. 1. " [75], "
hexmask.long.long 0x130 0.--31. 1. " [76], "
hexmask.long.long 0x134 0.--31. 1. " [77], "
hexmask.long.long 0x138 0.--31. 1. " [78], "
hexmask.long.long 0x13c 0.--31. 1. " [79], "
hexmask.long.long 0x140 0.--31. 1. " [80], "
hexmask.long.long 0x144 0.--31. 1. " [81], "
hexmask.long.long 0x148 0.--31. 1. " [82], "
hexmask.long.long 0x14c 0.--31. 1. " [83], "
hexmask.long.long 0x150 0.--31. 1. " [84], "
hexmask.long.long 0x154 0.--31. 1. " [85], "
hexmask.long.long 0x158 0.--31. 1. " [86], "
hexmask.long.long 0x15c 0.--31. 1. " [87], "
hexmask.long.long 0x160 0.--31. 1. " [88], "
hexmask.long.long 0x164 0.--31. 1. " [89], "
hexmask.long.long 0x168 0.--31. 1. " [90], "
hexmask.long.long 0x16c 0.--31. 1. " [91], "
hexmask.long.long 0x170 0.--31. 1. " [92], "
hexmask.long.long 0x174 0.--31. 1. " [93], "
hexmask.long.long 0x178 0.--31. 1. " [94], "
hexmask.long.long 0x17c 0.--31. 1. " [95], "
hexmask.long.long 0x180 0.--31. 1. " [96], "
hexmask.long.long 0x184 0.--31. 1. " [97], "
hexmask.long.long 0x188 0.--31. 1. " [98], "
hexmask.long.long 0x18c 0.--31. 1. " [99], "
hexmask.long.long 0x190 0.--31. 1. " [100], "
hexmask.long.long 0x194 0.--31. 1. " [101], "
hexmask.long.long 0x198 0.--31. 1. " [102], "
hexmask.long.long 0x19c 0.--31. 1. " [103], "
hexmask.long.long 0x1a0 0.--31. 1. " [104], "
hexmask.long.long 0x1a4 0.--31. 1. " [105], "
hexmask.long.long 0x1a8 0.--31. 1. " [106], "
hexmask.long.long 0x1ac 0.--31. 1. " [107], "
hexmask.long.long 0x1b0 0.--31. 1. " [108], "
hexmask.long.long 0x1b4 0.--31. 1. " [109], "
hexmask.long.long 0x1b8 0.--31. 1. " [110], "
hexmask.long.long 0x1bc 0.--31. 1. " [111], "
hexmask.long.long 0x1c0 0.--31. 1. " [112], "
hexmask.long.long 0x1c4 0.--31. 1. " [113], "
hexmask.long.long 0x1c8 0.--31. 1. " [114], "
hexmask.long.long 0x1cc 0.--31. 1. " [115], "
hexmask.long.long 0x1d0 0.--31. 1. " [116], "
hexmask.long.long 0x1d4 0.--31. 1. " [117], "
hexmask.long.long 0x1d8 0.--31. 1. " [118], "
hexmask.long.long 0x1dc 0.--31. 1. " [119], "
hexmask.long.long 0x1e0 0.--31. 1. " [120], "
hexmask.long.long 0x1e4 0.--31. 1. " [121], "
hexmask.long.long 0x1e8 0.--31. 1. " [122], "
hexmask.long.long 0x1ec 0.--31. 1. " [123], "
hexmask.long.long 0x1f0 0.--31. 1. " [124], "
hexmask.long.long 0x1f4 0.--31. 1. " [125], "
hexmask.long.long 0x1f8 0.--31. 1. " [126], "
hexmask.long.long 0x1fc 0.--31. 1. " [127], "
hexmask.long.long 0x200 0.--31. 1. " [128], "
hexmask.long.long 0x204 0.--31. 1. " [129], "
hexmask.long.long 0x208 0.--31. 1. " [130], "
hexmask.long.long 0x20c 0.--31. 1. " [131], "
hexmask.long.long 0x210 0.--31. 1. " [132], "
hexmask.long.long 0x214 0.--31. 1. " [133], "
hexmask.long.long 0x218 0.--31. 1. " [134], "
hexmask.long.long 0x21c 0.--31. 1. " [135], "
hexmask.long.long 0x220 0.--31. 1. " [136], "
hexmask.long.long 0x224 0.--31. 1. " [137], "
hexmask.long.long 0x228 0.--31. 1. " [138], "
hexmask.long.long 0x22c 0.--31. 1. " [139], "
hexmask.long.long 0x230 0.--31. 1. " [140], "
hexmask.long.long 0x234 0.--31. 1. " [141], "
hexmask.long.long 0x238 0.--31. 1. " [142], "
hexmask.long.long 0x23c 0.--31. 1. " [143], "
hexmask.long.long 0x240 0.--31. 1. " [144], "
hexmask.long.long 0x244 0.--31. 1. " [145], "
hexmask.long.long 0x248 0.--31. 1. " [146], "
hexmask.long.long 0x24c 0.--31. 1. " [147], "
hexmask.long.long 0x250 0.--31. 1. " [148], "
hexmask.long.long 0x254 0.--31. 1. " [149], "
hexmask.long.long 0x258 0.--31. 1. " [150], "
hexmask.long.long 0x25c 0.--31. 1. " [151], "
hexmask.long.long 0x260 0.--31. 1. " [152], "
hexmask.long.long 0x264 0.--31. 1. " [153], "
hexmask.long.long 0x268 0.--31. 1. " [154], "
hexmask.long.long 0x26c 0.--31. 1. " [155], "
hexmask.long.long 0x270 0.--31. 1. " [156], "
hexmask.long.long 0x274 0.--31. 1. " [157], "
hexmask.long.long 0x278 0.--31. 1. " [158], "
hexmask.long.long 0x27c 0.--31. 1. " [159], "
hexmask.long.long 0x280 0.--31. 1. " [160], "
hexmask.long.long 0x284 0.--31. 1. " [161], "
hexmask.long.long 0x288 0.--31. 1. " [162], "
hexmask.long.long 0x28c 0.--31. 1. " [163], "
hexmask.long.long 0x290 0.--31. 1. " [164], "
hexmask.long.long 0x294 0.--31. 1. " [165], "
hexmask.long.long 0x298 0.--31. 1. " [166], "
hexmask.long.long 0x29c 0.--31. 1. " [167], "
hexmask.long.long 0x2a0 0.--31. 1. " [168], "
hexmask.long.long 0x2a4 0.--31. 1. " [169], "
hexmask.long.long 0x2a8 0.--31. 1. " [170], "
hexmask.long.long 0x2ac 0.--31. 1. " [171], "
hexmask.long.long 0x2b0 0.--31. 1. " [172], "
hexmask.long.long 0x2b4 0.--31. 1. " [173], "
hexmask.long.long 0x2b8 0.--31. 1. " [174], "
hexmask.long.long 0x2bc 0.--31. 1. " [175], "
hexmask.long.long 0x2c0 0.--31. 1. " [176], "
hexmask.long.long 0x2c4 0.--31. 1. " [177], "
hexmask.long.long 0x2c8 0.--31. 1. " [178], "
hexmask.long.long 0x2cc 0.--31. 1. " [179], "
hexmask.long.long 0x2d0 0.--31. 1. " [180], "
hexmask.long.long 0x2d4 0.--31. 1. " [181], "
hexmask.long.long 0x2d8 0.--31. 1. " [182], "
hexmask.long.long 0x2dc 0.--31. 1. " [183], "
hexmask.long.long 0x2e0 0.--31. 1. " [184], "
hexmask.long.long 0x2e4 0.--31. 1. " [185], "
hexmask.long.long 0x2e8 0.--31. 1. " [186], "
hexmask.long.long 0x2ec 0.--31. 1. " [187], "
hexmask.long.long 0x2f0 0.--31. 1. " [188], "
hexmask.long.long 0x2f4 0.--31. 1. " [189], "
hexmask.long.long 0x2f8 0.--31. 1. " [190], "
hexmask.long.long 0x2fc 0.--31. 1. " [191], "
hexmask.long.long 0x300 0.--31. 1. " [192], "
hexmask.long.long 0x304 0.--31. 1. " [193], "
hexmask.long.long 0x308 0.--31. 1. " [194], "
hexmask.long.long 0x30c 0.--31. 1. " [195], "
hexmask.long.long 0x310 0.--31. 1. " [196], "
hexmask.long.long 0x314 0.--31. 1. " [197], "
hexmask.long.long 0x318 0.--31. 1. " [198], "
hexmask.long.long 0x31c 0.--31. 1. " [199], "
hexmask.long.long 0x320 0.--31. 1. " [200], "
hexmask.long.long 0x324 0.--31. 1. " [201], "
hexmask.long.long 0x328 0.--31. 1. " [202], "
hexmask.long.long 0x32c 0.--31. 1. " [203], "
hexmask.long.long 0x330 0.--31. 1. " [204], "
hexmask.long.long 0x334 0.--31. 1. " [205], "
hexmask.long.long 0x338 0.--31. 1. " [206], "
hexmask.long.long 0x33c 0.--31. 1. " [207], "
hexmask.long.long 0x340 0.--31. 1. " [208], "
hexmask.long.long 0x344 0.--31. 1. " [209], "
hexmask.long.long 0x348 0.--31. 1. " [210], "
hexmask.long.long 0x34c 0.--31. 1. " [211], "
hexmask.long.long 0x350 0.--31. 1. " [212], "
hexmask.long.long 0x354 0.--31. 1. " [213], "
hexmask.long.long 0x358 0.--31. 1. " [214], "
hexmask.long.long 0x35c 0.--31. 1. " [215], "
hexmask.long.long 0x360 0.--31. 1. " [216], "
hexmask.long.long 0x364 0.--31. 1. " [217], "
hexmask.long.long 0x368 0.--31. 1. " [218], "
hexmask.long.long 0x36c 0.--31. 1. " [219], "
hexmask.long.long 0x370 0.--31. 1. " [220], "
hexmask.long.long 0x374 0.--31. 1. " [221], "
hexmask.long.long 0x378 0.--31. 1. " [222], "
hexmask.long.long 0x37c 0.--31. 1. " [223], "
hexmask.long.long 0x380 0.--31. 1. " [224], "
TREE.END
TREE "gamma be1 mem"
group.long 0x12c00++0x4
line.long 0x0 "0x12c00"
button "Data 0x12c00" "B::Data.dump (0xFEC12C00) /DIALOG"
TREE.END
TREE "defect pixel mem"
group.long 0x13000++0x4
line.long 0x0 "0x13000"
button "Data 0x13000" "B::Data.dump (0xFEC13000) /DIALOG"
TREE.END
TREE "gamma fe mem"
group.long 0x14000++0x4
line.long 0x0 "0x14000"
button "Data 0x14000" "B::Data.dump (0xFEC14000) /DIALOG"
TREE.END
TREE "ca correction mem"
group.long 0x18000++0x4
line.long 0x0 "0x18000"
button "Data 0x18000" "B::Data.dump (0xFEC18000) /DIALOG"
TREE.END
TREE "shading mem"
group.long 0x1c000++0x4
line.long 0x0 "0x1c000"
button "Data 0x1c000" "B::Data.dump (0xFEC1C000) /DIALOG"
TREE.END
TREE.END
